Properties of the parts of a building model (IFC2X3), part 10 of 11

# IfcFlowSegment: Pipe Types:PVC_Baixant (578)
Name (Pipe Types:PVC_Baixant:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1370574 | Nivell 01 P01_PP | 0.22646 | 14.3246 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370582 | Nivell 01 P01_PP | 0.361417 | 13.9842 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370778 | Nivell 04 P04_PP | 1.48994 | 21.6977 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 31
1370780 | Nivell 04 P04_PP | 3.05233 | 21.6666 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 31
1370784 | Nivell 03 P03_PP | 0.837689 | 21.8223 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 31
1370788 | Nivell 04 P04_PP | 1.71164 | 21.5632 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 24
1370790 | Nivell 03 P03_PP | 0.989013 | 21.671 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 24
1370794 | Nivell 03 P03_PP | 2.89527 | 21.5338 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 24
1370814 | Nivell 04 P04_PP | 1.48994 | 21.6977 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 33
1370816 | Nivell 04 P04_PP | 3.05233 | 21.6666 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 33
1370820 | Nivell 03 P03_PP | 0.837689 | 21.8223 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 33
1370824 | Nivell 04 P04_PP | 1.68974 | 21.5766 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370826 | Nivell 03 P03_PP | 0.975843 | 21.6842 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370850 | Nivell 04 P04_PP | 3.1468 | 21.7939 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370852 | Nivell 03 P03_PP | 0.743932 | 21.9161 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370854 | Nivell 03 P03_PP | 0.218699 | 21.7913 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370872 | Nivell 03 P03_PP | 0.437689 | 22.2223 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370880 | Nivell 03 P03_PP | 3.4141 | 22.0784 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370882 | Nivell 03 P03_PP | 0.844595 | 22.0695 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370886 | Nivell 03 P03_PP | 18.5301 | 21.5295 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370888 | Nivell 03 P03_PP | 0.863185 | 21.5204 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370892 | Nivell 03 P03_PP | 0.179436 | 22.0672 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370894 | Nivell 03 P03_PP | 0.22646 | 21.8246 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370902 | Nivell 03 P03_PP | 0.361791 | 21.5162 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370906 | Nivell 03 P03_PP | 0.437689 | 22.2223 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370910 | Nivell 03 P03_PP | 3.4141 | 22.0784 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370912 | Nivell 03 P03_PP | 0.844595 | 22.0695 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370916 | Nivell 03 P03_PP | 18.5301 | 21.5295 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370918 | Nivell 03 P03_PP | 0.863185 | 21.5204 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370922 | Nivell 03 P03_PP | 0.179436 | 22.0672 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370924 | Nivell 03 P03_PP | 0.22646 | 21.8246 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370932 | Nivell 03 P03_PP | 0.361791 | 21.5162 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370953 | Nivell 05 P05_PP | 1.48994 | 25.4477 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 39
1370955 | Nivell 05 P05_PP | 3.05233 | 25.4166 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 39
1370959 | Nivell 04 P04_PP | 0.837689 | 25.5723 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 39
1370963 | Nivell 05 P05_PP | 1.71164 | 25.3132 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 30
1370965 | Nivell 04 P04_PP | 0.989013 | 25.421 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 30
1370969 | Nivell 04 P04_PP | 2.89527 | 25.2838 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 30
1370989 | Nivell 05 P05_PP | 1.48994 | 25.4477 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 41
1370991 | Nivell 05 P05_PP | 3.05233 | 25.4166 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 41
1370995 | Nivell 04 P04_PP | 0.837689 | 25.5723 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 41
1370999 | Nivell 05 P05_PP | 1.68974 | 25.3266 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371001 | Nivell 04 P04_PP | 0.975843 | 25.4342 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371025 | Nivell 05 P05_PP | 3.1468 | 25.5439 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371027 | Nivell 04 P04_PP | 0.743932 | 25.6661 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371029 | Nivell 04 P04_PP | 0.218699 | 25.5413 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371047 | Nivell 04 P04_PP | 0.437689 | 25.9723 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371055 | Nivell 04 P04_PP | 3.4141 | 25.8284 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371057 | Nivell 04 P04_PP | 0.844595 | 25.8195 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371061 | Nivell 04 P04_PP | 18.5301 | 25.2795 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371063 | Nivell 04 P04_PP | 0.863185 | 25.2704 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371067 | Nivell 04 P04_PP | 0.179436 | 25.8172 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371069 | Nivell 04 P04_PP | 0.22646 | 25.5746 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371077 | Nivell 04 P04_PP | 0.361791 | 25.2662 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371081 | Nivell 04 P04_PP | 0.437689 | 25.9723 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371085 | Nivell 04 P04_PP | 3.4141 | 25.8284 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371087 | Nivell 04 P04_PP | 0.844595 | 25.8195 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371091 | Nivell 04 P04_PP | 18.5301 | 25.2795 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371093 | Nivell 04 P04_PP | 0.863185 | 25.2704 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371097 | Nivell 04 P04_PP | 0.179436 | 25.8172 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371099 | Nivell 04 P04_PP | 0.22646 | 25.5746 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371107 | Nivell 04 P04_PP | 0.361791 | 25.2662 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1372913 | Nivell 03 P03_PP | 1.48994 | 17.9477 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 27
1372915 | Nivell 03 P03_PP | 4.95223 | 17.8976 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 27
1372919 | Nivell 02 P02_PP | 0.837689 | 18.0723 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 27
1372923 | Nivell 03 P03_PP | 1.70401 | 17.8453 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 21
1372925 | Nivell 02 P02_PP | 0.957011 | 17.953 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 21
1372929 | Nivell 02 P02_PP | 4.85507 | 17.7963 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 21
1372949 | Nivell 03 P03_PP | 1.48994 | 17.9477 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 29
1372951 | Nivell 03 P03_PP | 4.95223 | 17.8976 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 29
1372955 | Nivell 02 P02_PP | 0.837689 | 18.0723 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 29
1372959 | Nivell 03 P03_PP | 1.7093 | 17.8179 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372961 | Nivell 02 P02_PP | 0.984326 | 17.9257 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372965 | Nivell 02 P02_PP | 4.44314 | 17.773 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372985 | Nivell 03 P03_PP | 3.14681 | 18.0429 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372987 | Nivell 02 P02_PP | 0.744932 | 18.1651 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372989 | Nivell 02 P02_PP | 0.218578 | 18.0403 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1373007 | Nivell 02 P02_PP | 0.437689 | 18.4723 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373015 | Nivell 02 P02_PP | 3.4141 | 18.3284 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373017 | Nivell 02 P02_PP | 0.844595 | 18.3195 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373021 | Nivell 02 P02_PP | 21.7301 | 17.7475 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373023 | Nivell 02 P02_PP | 0.863262 | 17.7384 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373027 | Nivell 02 P02_PP | 0.179436 | 18.3172 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373029 | Nivell 02 P02_PP | 0.22646 | 18.0746 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373037 | Nivell 02 P02_PP | 0.361417 | 17.7342 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373041 | Nivell 02 P02_PP | 0.437689 | 18.4723 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373045 | Nivell 02 P02_PP | 3.4141 | 18.3284 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373047 | Nivell 02 P02_PP | 0.844595 | 18.3195 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373051 | Nivell 02 P02_PP | 21.7301 | 17.7475 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373053 | Nivell 02 P02_PP | 0.863262 | 17.7384 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373057 | Nivell 02 P02_PP | 0.179436 | 18.3172 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373059 | Nivell 02 P02_PP | 0.22646 | 18.0746 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373067 | Nivell 02 P02_PP | 0.361417 | 17.7342 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1374760 | Nivell 00 P00_PB | 1.45227 | 7.27674 | 04_SN_AGRIS 6
1374811 | Nivell 00 P00_PB | 1.04813 | 7.38187 | 04_SN_AGRIS 6
1374983 | Nivell 00 P00_PB | 1.34802 | 7.32384 | 04_SN_AGRIS 7
1374998 | Nivell 00 P00_PB | 3.90732 | 7.28433 | 04_SN_AGRIS 7
1375077 | Nivell 00 P00_PB | 0.882006 | 7.42799 | 04_SN_AGRIS 7
1375136 | Nivell 00 P00_PB | 1.61089 | 7.2034 | 04_SN_AFEC 10
1375145 | Nivell 00 P00_PB | 4.27081 | 7.1601 | 04_SN_AFEC 10
1375394 | Nivell 00 P00_PB | 2.78369 | 7.44061 | 04_SN_AGRIS 3
1377469 | Nivell -01 PS1_PK | 0.412218 | 6.75778 | 04_SN_APLU 9
1377645 | Nivell -01 PS1_PK | 13.6055 | 6.4971 | 04_SN_APLU 9
1377938 | Nivell -01 PS1_PK | 1.32848 | 7.24334 | 04_SN_AGRIS 6
1378033 | Nivell 00 P00_PB | 0.961451 | 7.36855 | 04_SN_AGRIS 6
1380293 | Nivell -01 PS1_PK | 1.93463 | 8.86931 | 04_SN_APLU 25
1382655 | Nivell -01 PS1_PK | 7.17152 | 5.32711 | 04_SN_APLU 20
1382936 | Nivell -03 PS2_PK | 9.70852 | 0.999223 | 04_SN_APLU 24
1382944 | Nivell -03 PS2_PK | 0.257786 | 1.09721 | 04_SN_APLU 24
1383023 | Nivell -03 PS2_PK | 0.369976 | 0.994616 | 04_SN_APLU 24
1383042 | Nivell -03 PS2_PK | 4.49431 | 0.948768 | 04_SN_APLU 24
1383052 | Nivell -03 PS2_PK | 3.50554 | 0.912807 | 04_SN_APLU 24
1383062 | Nivell -03 PS2_PK | 2.83792 | 0.883522 | 04_SN_APLU 24
1383553 | Nivell 00 P00_PB | 0.6985 | 1.35593 | 04_SN_AFEC 23
1383673 | Nivell -01 PS1_PK | 3.08969 | 1.20041 | 04_SN_AFEC 13
1383774 | Nivell -03 PS2_PK | 21.6803 | -2.05894 | 04_SN_AFEC 13
1383807 | Nivell -03 PS2_PK | 0.997694 | -2.07205 | 04_SN_AFEC 13
1383817 | Nivell -03 PS2_PK | 0.970471 | -2.08235 | 04_SN_AFEC 13
1383842 | Nivell -03 PS2_PK | 1.29046 | -2.1852 | 04_SN_ABOM 1
1383851 | Nivell -03 PS2_PK | 0.503669 | 0.8148 | 04_SN_ABOM 1
1383895 | Nivell -03 PS2_PK | 2.78093 | -1.99046 | 04_SN_ABOM 1
1383904 | Nivell -03 PS2_PK | 30.7593 | 0.8148 | 04_SN_ABOM 1
1383915 | Nivell -03 PS2_PK | 0.745091 | 0.8148 | 04_SN_ABOM 1
1383923 | Nivell -01 PS1_PK | 0.210565 | 4.5648 | 04_SN_ABOM 1
1383987 | Nivell -03 PS2_PK | 3.53093 | 1.00954 | 04_SN_ABOM 1
1384076 | Nivell -01 PS1_PK | 0.420468 | 5.35763 | 04_SN_AFEC 18
1384085 | Nivell -01 PS1_PK | 0.266632 | 5.41467 | 04_SN_AFEC 18
1384094 | Nivell -01 PS1_PK | 0.987979 | 5.58752 | 04_SN_AFEC 18
1384177 | Nivell -01 PS1_PK | 0.248011 | 5.41467 | 04_SN_AFEC 18
1384781 | Nivell -01 PS1_PK | 1.13871 | 5.61033 | 04_SN_AFEC 18
1385173 | Nivell -01 PS1_PK | 0.7 | 1.28719 | 04_SN_AFEC 22
1385236 | Nivell -03 PS2_PK | 0.842912 | 1.15509 | 04_SN_AFEC 13
1385247 | Nivell -03 PS2_PK | 20.5159 | 0.946798 | 04_SN_AFEC 13
1385263 | Nivell -03 PS2_PK | 6.29239 | 0.883285 | 04_SN_AFEC 13
1385277 | Nivell -03 PS2_PK | 1.45965 | 0.868098 | 04_SN_AFEC 13
1385288 | Nivell -03 PS2_PK | 1.74085 | 0.850098 | 04_SN_AFEC 13
1385298 | Nivell -03 PS2_PK | 1.54968 | 0.834011 | 04_SN_AFEC 13
1391914 | Nivell 05 P05_PP | 1.02407 | 29.2066 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1391927 | Nivell 05 P05_PP | 0.125743 | 29.2173 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1391941 | Nivell 05 P05_PP | 7.18556 | 29.219 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1392446 | Nivell 03 P03_PP | 1.02407 | 21.7066 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1392450 | Nivell 03 P03_PP | 0.125743 | 21.7173 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1392452 | Nivell 03 P03_PP | 7.18556 | 21.719 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1392471 | Nivell 04 P04_PP | 1.02407 | 25.4566 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1392475 | Nivell 04 P04_PP | 0.125743 | 25.4673 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1392477 | Nivell 04 P04_PP | 7.18556 | 25.469 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1392556 | Nivell 01 P01_PP | 1.19668 | 14.2044 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1392613 | Nivell 01 P01_PP | 0.192312 | 14.2167 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1392629 | Nivell 01 P01_PP | 7.08774 | 14.219 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1392880 | Nivell 02 P02_PP | 1.19668 | 17.9544 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1392884 | Nivell 02 P02_PP | 0.192312 | 17.9667 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1392886 | Nivell 02 P02_PP | 7.08774 | 17.969 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1399437 | Nivell -03 PS2_PK | 2.44455 | -1.62877 | 04_SN_AFEC 13
1399555 | Nivell -03 PS2_PK | 0.805918 | -2.05894 | 04_SN_AFEC 13
1399569 | Nivell -03 PS2_PK | 0.147076 | -1.92625 | 04_SN_AFEC 13
1399572 | Nivell -03 PS2_PK | 0.752852 | -1.76093 | 04_SN_AFEC 13
1404196 | Nivell 07 P07_PP | 2.69859 | 7.41 | 04_SN_AGRIS 11
1404377 | Nivell 07 P07_PP | 22.7702 | 10.1086 | 04_SN_AGRIS 13
1432108 | Nivell 01 P01_PP | 4.94834 | 10.3779 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1432117 | Nivell 01 P01_PP | 0.764142 | 10.5959 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 19
1432128 | Nivell 01 P01_PP | 1.25846 | 10.8215 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432134 | Nivell 00 P00_PB | 0.486185 | 10.9438 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432139 | Nivell 00 P00_PB | 0.854318 | 10.5757 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432150 | Nivell 01 P01_PP | 3.14639 | 10.5111 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432151 | Nivell 00 P00_PB | 0.796718 | 10.6333 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432152 | Nivell 00 P00_PB | 0.218073 | 10.5085 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432154 | Nivell 00 P00_PB | 0.406782 | 11.0232 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432160 | Nivell 00 P00_PB | 6.35564 | 10.8499 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432162 | Nivell 00 P00_PB | 0.844591 | 10.841 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432172 | Nivell 00 P00_PB | 0.329429 | 10.8372 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432174 | Nivell 00 P00_PB | 0.31901 | 10.502 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432186 | Nivell 00 P00_PB | 0.402689 | 11.0273 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432190 | Nivell 00 P00_PB | 6.91428 | 10.8484 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432192 | Nivell 00 P00_PB | 0.844595 | 10.8395 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432196 | Nivell 00 P00_PB | 6.72934 | 10.2675 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432198 | Nivell 00 P00_PB | 0.863262 | 10.2584 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432202 | Nivell 00 P00_PB | 0.179436 | 10.8372 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432204 | Nivell 00 P00_PB | 0.37646 | 10.4446 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432212 | Nivell 00 P00_PB | 0.911613 | 10.2487 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1435170 | Nivell -03 PS2_PK | 4.47285 | 1.15509 | 04_SN_AFEC 13
1435701 | Nivell -03 PS2_PK | 0.67632 | 1.30663 | 04_SN_AFEC 24
1435891 | Nivell -01 PS1_PK | 5.59906 | 1.12601 | 04_SN_AFEC 24
1435956 | Nivell -03 PS2_PK | 1.34163 | 1.112 | 04_SN_AFEC 24
1436016 | Nivell -03 PS2_PK | 0.731872 | 1.10409 | 04_SN_AFEC 24
1436283 | Nivell -03 PS2_PK | 14.3554 | 1.05497 | 04_SN_AGRIS 4
1441172 | Nivell 06 P06_PP | 0.0596556 | 33.3367 | 04_SN_APLU 3
1441481 | Nivell 06 P06_PP | 0.50181 | 32.964 | 04_SN_APLU 3
1441522 | Nivell 06 P06_PP | 0.205421 | 33.0937 | 04_SN_APLU 3
1442067 | Nivell 06 P06_PP | 0.204472 | 33.3173 | 04_SN_APLU 3
1442567 | Nivell 06 P06_PP | 0.96084 | 33.3265 | 04_SN_APLU 3
1442575 | Nivell 06 P06_PP | 0.343701 | 33.3225 | 04_SN_APLU 3
1442859 | Nivell 06 P06_PP | 1.28274 | 33.3225 | 04_SN_APLU 3
1442894 | Nivell 06 P06_PP | 0.0579214 | 33.3368 | 04_SN_APLU 1
1442896 | Nivell 06 P06_PP | 0.2087 | 33.0904 | 04_SN_APLU 1
1442902 | Nivell 06 P06_PP | 0.204472 | 33.3173 | 04_SN_APLU 1
1442906 | Nivell 06 P06_PP | 0.963292 | 33.3265 | 04_SN_APLU 1
1442908 | Nivell 06 P06_PP | 0.343701 | 33.3225 | 04_SN_APLU 1
1443067 | Nivell 06 P06_PP | 1.28274 | 33.3225 | 04_SN_APLU 1
1455548 | Nivell 06 P06_PP | 9.82544 | 33.1137 | 04_SN_AFEC 25
1455622 | Nivell 06 P06_PP | 0.120017 | 33.0241 | 04_SN_AFEC 25
1460443 | Nivell 00 P00_PB | 1.48808 | 10.4903 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 19
1460453 | Nivell 00 P00_PB | 4.96961 | 10.4403 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 19
1462583 | Nivell 05 P05_PP | 0.0247622 | 29.1677 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1462968 | Nivell 03 P03_PP | 0.0247622 | 21.6677 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1462992 | Nivell 04 P04_PP | 0.0247622 | 25.4177 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1463576 | Nivell 05 P05_PP | 0.0485964 | 29.0504 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1463887 | Nivell 03 P03_PP | 0.0485964 | 21.5504 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1463894 | Nivell 04 P04_PP | 0.0485964 | 25.3004 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1463986 | Nivell 05 P05_PP | 2.59758 | 29.0513 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464316 | Nivell 05 P05_PP | 2.57934 | 29.0504 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464339 | Nivell 05 P05_PP | 0.34 | 29.0447 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464592 | Nivell 03 P03_PP | 2.59758 | 21.5513 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464600 | Nivell 03 P03_PP | 2.57934 | 21.5504 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464602 | Nivell 03 P03_PP | 0.34 | 21.5447 | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464611 | Nivell 04 P04_PP | 2.59758 | 25.3013 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464619 | Nivell 04 P04_PP | 2.57934 | 25.3004 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464621 | Nivell 04 P04_PP | 0.34 | 25.2947 | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464729 | Nivell 02 P02_PP | 2.46668 | 17.7765 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464738 | Nivell 02 P02_PP | 0.048407 | 17.8918 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464746 | Nivell 02 P02_PP | 0.305097 | 17.773 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464759 | Nivell 02 P02_PP | 0.322827 | 17.7676 | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464953 | Nivell 01 P01_PP | 2.46668 | 14.0265 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1464955 | Nivell 01 P01_PP | 0.048407 | 14.1418 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1464961 | Nivell 01 P01_PP | 0.305097 | 14.023 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1464965 | Nivell 01 P01_PP | 0.322827 | 14.0176 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1477088 | Nivell -01 PS1_PK | 1.2068 | 5.97116 | 04_SN_AFEC 9
1477094 | Nivell 00 P00_PB | 2.66589 | 7.07486 | 04_SN_AFEC 10
1477096 | Nivell 00 P00_PB | 0.493159 | 7.10242 | 04_SN_AFEC 10
1478564 | Nivell -01 PS1_PK | 15.6655 | 5.66475 | 04_SN_AGRIS 7
1478648 | Nivell 00 P00_PB | 2.128 | 7.28429 | 04_SN_AGRIS 7
1481489 | Nivell 00 P00_PB | 0.0723511 | 10.8419 | 04_SN_AGRIS 18
1481498 | Nivell 00 P00_PB | 0.100099 | 10.8405 | 04_SN_AGRIS 18
1481529 | Nivell 00 P00_PB | 0.0417933 | 10.8396 | 04_SN_AGRIS 18
1481787 | Nivell 00 P00_PB | 2.91376 | 7.37004 | 04_SN_AFEC 11
1482727 | Nivell 00 P00_PB | 0.229223 | 7.27326 | 04_SN_AGRIS 7
1482834 | Nivell 00 P00_PB | 0.438525 | 7.27939 | 04_SN_AGRIS 7
1482947 | Nivell 00 P00_PB | 2.81335 | 7.24239 | 04_SN_AGRIS 7
1483285 | Nivell 00 P00_PB | 0.32711 | 7.15624 | 04_SN_AFEC 10
1483313 | Nivell 00 P00_PB | 0.101286 | 7.1257 | 04_SN_AFEC 10
1483547 | Nivell 00 P00_PB | 1.2459 | 7.10826 | 04_SN_AFEC 10
1484059 | Nivell 00 P00_PB | 1.29753 | 5.92873 | 04_SN_AGRIS 7
1484301 | Nivell -01 PS1_PK | 15.4175 | 5.62228 | 04_SN_AFEC 9
1484562 | Nivell -01 PS1_PK | 0.607596 | 5.6153 | 04_SN_AFEC 9
1484607 | Nivell -01 PS1_PK | 0.831913 | 5.65591 | 04_SN_AGRIS 7
1495144 | Nivell 00 P00_PB | 2.22386 | 10.3551 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1497950 | Nivell -01 PS1_PK | 2.11901 | 5.59023 | 04_SN_AFEC 9
1497990 | Nivell -01 PS1_PK | 0.295157 | 5.32073 | 04_SN_AFEC 24
1498017 | Nivell -01 PS1_PK | 2.35138 | 5.62916 | 04_SN_AGRIS 7
1498087 | Nivell -01 PS1_PK | 0.42634 | 5.23428 | 04_SN_AGRIS 4
1500439 | Nivell -01 PS1_PK | 5.7922 | 5.63847 | 04_SN_APLU 9
1500443 | Nivell -01 PS1_PK | 0.518381 | 5.45378 | 04_SN_APLU 9
1500453 | Nivell 00 P00_PB | 1.24767 | 6.00458 | 04_SN_AGRIS 20
1500463 | Nivell 00 P00_PB | 1.06815 | 6.15811 | 04_SN_AFEC 9
1500562 | Nivell 00 P00_PB | 2.66649 | 7.17984 | 04_SN_AGRIS 23
1500574 | Nivell 00 P00_PB | 1.269 | 7.20703 | 04_SN_AGRIS 23
1500578 | Nivell 00 P00_PB | 1.11392 | 7.22024 | 04_SN_AGRIS 23
1502873 | Nivell -01 PS1_PK | 1.74865 | 6.10357 | 04_SN_AGRIS 7
1503331 | Nivell -01 PS1_PK | 0.259933 | 6.10366 | 04_SN_AGRIS 7
1503358 | Nivell -01 PS1_PK | 0.324208 | 5.76705 | 04_SN_AGRIS 7
1503359 | Nivell -01 PS1_PK | 0.023837 | 6.1074 | 04_SN_AGRIS 7
1503363 | Nivell -01 PS1_PK | 0.132701 | 5.65406 | 04_SN_AGRIS 7
1503770 | Nivell -01 PS1_PK | 1.98114 | 5.98227 | 04_SN_AFEC 9
1503778 | Nivell -01 PS1_PK | 0.454845 | 5.97699 | 04_SN_AFEC 9
1504215 | Nivell -01 PS1_PK | 0.502764 | 5.97124 | 04_SN_AFEC 9
1504310 | Nivell -01 PS1_PK | 0.0861486 | 5.86525 | 04_SN_AFEC 9
1504326 | Nivell -01 PS1_PK | 0.065617 | 5.61373 | 04_SN_AFEC 9
1505115 | Nivell 00 P00_PB | 1.74533 | 7.25885 | 04_SN_AGRIS 6
1505240 | Nivell 00 P00_PB | 1.9017 | 7.25885 | 04_SN_AGRIS 6
1505955 | Nivell -03 PS2_PK | 0.191607 | 1.30291 | 04_SN_AGRIS 4
1505976 | Nivell -03 PS2_PK | 2.48544 | 1.41456 | 04_SN_AGRIS 4
1506036 | Nivell -03 PS2_PK | 5.66764 | 1.24813 | 04_SN_AGRIS 4
1506055 | Nivell -03 PS2_PK | 0.327825 | 1.24434 | 04_SN_AGRIS 4
1506160 | Nivell -03 PS2_PK | 1.48868 | 1.20518 | 04_SN_AGRIS 4
1506168 | Nivell -03 PS2_PK | 0.340772 | 1.20125 | 04_SN_AGRIS 4
1506244 | Nivell -03 PS2_PK | 4.25756 | 1.20125 | 04_SN_AGRIS 4
1506608 | Nivell -03 PS2_PK | 0.400638 | 0.967295 | 04_SN_AFEC 24
1506649 | Nivell -01 PS1_PK | 9.96896 | 1.00382 | 04_SN_AFEC 24
1507507 | Nivell -03 PS2_PK | 0.58017 | 4.74644 | 04_SN_AGRIS 4
1507525 | Nivell -03 PS2_PK | 3.40524 | 1.32979 | 04_SN_AGRIS 4
1507611 | Nivell -03 PS2_PK | 0.539256 | 4.80172 | 04_SN_AFEC 24
1507626 | Nivell -03 PS2_PK | 3.59984 | 1.18467 | 04_SN_AFEC 24
1508489 | Nivell -03 PS2_PK | 14.4817 | 0.817504 | 04_SN_AFEC 24
1508495 | Nivell -03 PS2_PK | 0.307912 | 0.967295 | 04_SN_AFEC 24
1508505 | Nivell -03 PS2_PK | 1.86574 | 0.971282 | 04_SN_AFEC 24
1508720 | Nivell 00 P00_PB | 1.99657 | 5.92073 | 04_SN_AFEC 7
1509169 | Nivell -01 PS1_PK | 6.33494 | 5.54107 | 04_SN_AFEC 16
1509508 | Nivell -01 PS1_PK | 1.85463 | 6.99747 | 04_SN_APLU 25
1509565 | Nivell -01 PS1_PK | 0.610478 | 5.73952 | 04_SN_APLU 9
1514038 | Nivell -01 PS1_PK | 2.39871 | 5.40205 | 04_SN_APLU 9
1529430 | Nivell -01 PS1_PK | 0.732015 | 6.08635 | 04_SN_APLU 11
1529979 | Nivell 00 P00_PB | 0.629272 | 5.95073 | 04_SN_AFEC 28
1532642 | Nivell 01 P01_PP | 0.917976 | 10.8249 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1532646 | Nivell 00 P00_PB | 0.486199 | 10.9438 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1532780 | Nivell 00 P00_PB | 0.486182 | 10.9438 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1532797 | Nivell 01 P01_PP | 2.37494 | 10.8103 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1532799 | Nivell 00 P00_PB | 0.486191 | 10.9438 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1532818 | Nivell 00 P00_PB | 0.484801 | 10.9432 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533016 | Nivell 01 P01_PP | 1.48885 | 10.8103 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533030 | Nivell 01 P01_PP | 0.612552 | 10.828 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533137 | Nivell 01 P01_PP | 0.272541 | 10.5213 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533181 | Nivell 01 P01_PP | 0.282456 | 10.5113 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533266 | Nivell 01 P01_PP | 0.314979 | 10.49 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533489 | Nivell 00 P00_PB | 2.15706 | 10.827 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1534124 | Nivell 00 P00_PB | 0.23327 | 10.4721 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 22
1534648 | Nivell 00 P00_PB | 5.00703 | 10.4349 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1534729 | Nivell 00 P00_PB | 1.62019 | 10.4183 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1535386 | Nivell 00 P00_PB | 0.157685 | 3.781 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 26
1535426 | Nivell 00 P00_PB | 0.419046 | 11.0109 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535430 | Nivell 00 P00_PB | 5.11349 | 10.8501 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535432 | Nivell 00 P00_PB | 1.0724 | 10.8388 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535436 | Nivell 00 P00_PB | 14.1427 | 10.3412 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535438 | Nivell 00 P00_PB | 0.178887 | 10.8365 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535598 | Nivell 00 P00_PB | 0.228079 | 10.5923 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1536130 | Nivell 00 P00_PB | 0.273401 | 10.4257 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1536479 | Nivell 00 P00_PB | 1.30491 | 10.4112 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1536494 | Nivell 00 P00_PB | 8.16269 | 10.4265 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1536851 | Nivell 00 P00_PB | 0.145819 | 10.5633 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1537271 | Nivell 00 P00_PB | 1.52239 | 10.7275 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1537279 | Nivell 00 P00_PB | 0.105419 | 10.7293 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1537341 | Nivell 00 P00_PB | 0.159896 | 10.6853 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537350 | Nivell 00 P00_PB | 1.56638 | 10.6687 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537364 | Nivell 00 P00_PB | 1.4132 | 10.4326 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537419 | Nivell 00 P00_PB | 0.00290408 | 10.6414 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537429 | Nivell 00 P00_PB | 5.1696 | 10.38 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537439 | Nivell 00 P00_PB | 0.42929 | 10.3748 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537455 | Nivell 00 P00_PB | 0.369254 | 10.3702 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1538051 | Nivell 00 P00_PB | 0.551577 | 10.3696 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1538490 | Nivell 00 P00_PB | 0.478135 | 10.3585 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538507 | Nivell 00 P00_PB | 0.201227 | 10.3559 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538844 | Nivell 00 P00_PB | 0.21848 | 10.5925 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538847 | Nivell 00 P00_PB | 0.886477 | 10.43 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1539315 | Nivell 00 P00_PB | 0.109253 | 10.4105 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1539484 | Nivell 01 P01_PP | 0.109032 | 10.4005 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1539547 | Nivell 00 P00_PB | 1.66546 | 10.3724 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1539910 | Nivell 01 P01_PP | 0.541114 | 10.3639 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540165 | Nivell 01 P01_PP | 0.109786 | 10.3724 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540530 | Nivell 00 P00_PB | 2.13584 | 10.4031 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540547 | Nivell 00 P00_PB | 0.681144 | 10.3928 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1541010 | Nivell 00 P00_PB | 4.56689 | 7.23191 | 04_SN_AFEC 16
1541012 | Nivell 00 P00_PB | 0.666351 | 7.22473 | 04_SN_AFEC 16
1541020 | Nivell 00 P00_PB | 0.529989 | 7.38731 | 04_SN_AFEC 16
1541109 | Nivell 00 P00_PB | 2.68227 | 7.19739 | 04_SN_AFEC 16
1541201 | Nivell 00 P00_PB | 1.16934 | 5.96031 | 04_SN_AFEC 16
1541593 | Nivell -01 PS1_PK | 0.0672828 | 5.60532 | 04_SN_AFEC 16
1541606 | Nivell -01 PS1_PK | 3.72304 | 5.6069 | 04_SN_AFEC 16
1541956 | Nivell 00 P00_PB | 6.87976 | 10.3235 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1542365 | Nivell 00 P00_PB | 8.00959 | 10.2745 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1543611 | Nivell -01 PS1_PK | 0.35002 | 5.76209 | 04_SN_AFEC 16
1543623 | Nivell -01 PS1_PK | 0.266378 | 5.75844 | 04_SN_AFEC 16
1544608 | Nivell 01 P01_PP | 3.53099 | 14.1766 | 04_SN_APLU 21
1544626 | Nivell 01 P01_PP | 1.13084 | 14.1647 | 04_SN_APLU 21
1544636 | Nivell 01 P01_PP | 5.33041 | 14.1108 | 04_SN_APLU 21
1546036 | Nivell 01 P01_PP | 0.28084 | 14.2125 | 04_SN_APLU 21
1546176 | Nivell 01 P01_PP | 5.654 | 14.2159 | 04_SN_APLU 21
1546182 | Nivell 01 P01_PP | 0.0804169 | 14.2731 | 04_SN_APLU 21
1546248 | Nivell 01 P01_PP | 3.53099 | 14.1766 | 04_SN_APLU 16
1546250 | Nivell 01 P01_PP | 1.15086 | 14.1646 | 04_SN_APLU 16
1546254 | Nivell 01 P01_PP | 5.31625 | 14.1108 | 04_SN_APLU 16
1546258 | Nivell 01 P01_PP | 0.28084 | 14.2125 | 04_SN_APLU 16
1546264 | Nivell 01 P01_PP | 5.654 | 14.2159 | 04_SN_APLU 16
1546266 | Nivell 01 P01_PP | 0.0804169 | 14.2731 | 04_SN_APLU 16
1546756 | Nivell 04 P04_PP | 7.08746 | 14.2839 | 04_SN_APLU 6
1546902 | Nivell 00 P00_PB | 1.62475 | 6.48026 | 04_SN_APLU 9
1546938 | Nivell 00 P00_PB | 10.3025 | 6.37665 | 04_SN_APLU 9
1547090 | Nivell 00 P00_PB | 7.78451 | 6.29822 | 04_SN_APLU 9
1547102 | Nivell -01 PS1_PK | 1.91708 | 6.27846 | 04_SN_APLU 9
1547989 | Nivell -01 PS1_PK | 0.216428 | 5.42886 | 04_SN_APLU 9
1548039 | Nivell -01 PS1_PK | 0.295737 | 5.43214 | 04_SN_APLU 9
1548053 | Nivell -01 PS1_PK | 1.64448 | 5.43621 | 04_SN_APLU 9
1548432 | Nivell -01 PS1_PK | 9.73371 | 6.18053 | 04_SN_APLU 9
1548539 | Nivell -01 PS1_PK | 0.341278 | 5.82102 | 04_SN_APLU 9
1549248 | Nivell -01 PS1_PK | 7.87822 | 5.67447 | 04_SN_AFEC 16
1549258 | Nivell -01 PS1_PK | 0.226591 | 5.67127 | 04_SN_AFEC 16
1549274 | Nivell -01 PS1_PK | 1.93008 | 5.65107 | 04_SN_AFEC 16
1549387 | Nivell -01 PS1_PK | 0.512119 | 5.64504 | 04_SN_AFEC 16
1556988 | Nivell -01 PS1_PK | 0.150125 | 5.03284 | 04_SN_APLU 23
1556990 | Nivell -01 PS1_PK | 0.228942 | 5.27427 | 04_SN_APLU 23
1556994 | Nivell -01 PS1_PK | 0.925063 | 5.32284 | 04_SN_APLU 23
1556996 | Nivell -01 PS1_PK | 0.020125 | 5.27427 | 04_SN_APLU 23
1558109 | Nivell -01 PS1_PK | 0.422486 | 5.29037 | 04_SN_AFEC 16
1558111 | Nivell -01 PS1_PK | 0.263805 | 5.3474 | 04_SN_AFEC 16
1558113 | Nivell -01 PS1_PK | 1.44943 | 5.51564 | 04_SN_AFEC 16
1558115 | Nivell -01 PS1_PK | 0.248011 | 5.3474 | 04_SN_AFEC 16
1558125 | Nivell -01 PS1_PK | 0.150125 | 5.03284 | 04_SN_APLU 14
1558127 | Nivell -01 PS1_PK | 0.00314629 | 5.27427 | 04_SN_APLU 14
1558131 | Nivell -01 PS1_PK | 1.64452 | 5.28252 | 04_SN_APLU 18
1558133 | Nivell -01 PS1_PK | 0.00349427 | 5.27078
1558527 | Nivell -01 PS1_PK | 0.358898 | 4.16589 | 04_SN_APLU 20
1558538 | Nivell -01 PS1_PK | 0.938565 | 4.3642 | 04_SN_APLU 20
1558547 | Nivell -01 PS1_PK | 1.83187 | 1.33 | 04_SN_APLU 20
1558997 | Nivell -01 PS1_PK | 17.1441 | 3.19372 | 04_SN_APLU 20
1559616 | Nivell -01 PS1_PK | 0.747909 | 3.39364 | 04_SN_APLU 20
1560159 | Nivell -01 PS1_PK | 0.988826 | 5.78621 | 04_SN_AFEC 7
1580776 | Nivell 00 P00_PB | 2.21456 | 10.1434 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1580789 | Nivell 00 P00_PB | 0.362839 | 5.66738 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1580815 | Nivell 00 P00_PB | 4.11557 | 6.00959 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1580837 | Nivell 00 P00_PB | 0.617248 | 10.3168 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1580855 | Nivell 00 P00_PB | 0.526904 | 10.1671 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1581086 | Nivell -01 PS1_PK | 0.200921 | 5.88961 | 04_SN_APLU 11
1581133 | Nivell -01 PS1_PK | 10.5583 | 5.53165 | 04_SN_APLU 23
1581159 | Nivell -01 PS1_PK | 10.6475 | 5.55222 | 04_SN_APLU 20
1581423 | Nivell 00 P00_PB | 6.70925 | 10.3704 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1581763 | Nivell -01 PS1_PK | 1.49831 | 5.81111 | 04_SN_AFEC 28
1581907 | Nivell -01 PS1_PK | 1.968 | 3.55988 | 04_SN_APLU 20
1584634 | Nivell 00 P00_PB | 0.859225 | 9.75573 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1584654 | Nivell 00 P00_PB | 2.35328 | 7.03744 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1584896 | Nivell 00 P00_PB | 6.96052 | 10.2857 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1585047 | Nivell -01 PS1_PK | 0.885782 | 5.91908 | 04_SN_AFEC 18
1585349 | Nivell -01 PS1_PK | 9.35047 | 5.62403 | 04_SN_AFEC 18
1585359 | Nivell -01 PS1_PK | 0.591655 | 5.71844 | 04_SN_AFEC 18
1585699 | Nivell 00 P00_PB | 0.263402 | 9.84153 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1585710 | Nivell 00 P00_PB | 0.471473 | 6.8747 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1585913 | Nivell 00 P00_PB | 0.611232 | 9.78543 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586019 | Nivell 00 P00_PB | 0.229866 | 10.1178 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586108 | Nivell 00 P00_PB | 2.52792 | 6.99934 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586341 | Nivell 00 P00_PB | 0.0591705 | 6.8427 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1589224 | Nivell 00 P00_PB | 0.01541 | 10.1738 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1589225 | Nivell 00 P00_PB | 0.0888795 | 10.2084 | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1593802 | Nivell -01 PS1_PK | 0.315949 | 6.37713 | 04_SN_APLU 9
1593856 | Nivell -01 PS1_PK | 2.2926 | 6.3533 | 04_SN_APLU 9
1593928 | Nivell -01 PS1_PK | 0.433038 | 5.8946 | 04_SN_APLU 9
1593931 | Nivell -01 PS1_PK | 12.1641 | 5.46007 | 04_SN_APLU 9
1594649 | Nivell 06 P06_PP | 1.94491 | 11.7757 | 04_SN_APLU 11
1594669 | Nivell 06 P06_PP | 0.558798 | 10.0575 | 04_SN_APLU 11
1594946 | Nivell 06 P06_PP | 1.56972 | 10.1877 | 04_SN_APLU 11
1594960 | Nivell 06 P06_PP | 0.0987348 | 9.94054 | 04_SN_APLU 11
1595825 | Nivell -01 PS1_PK | 0.832645 | 4.75954 | 04_SN_ABOM 1

# IfcFlowSegment: Rectangular Duct:APT_Fibra de vidre rígida (50)
Type - Pset_ManufacturerTypeInformation - Manufacturer: ISOVER
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: APT_Fibra de vidre rígida; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:APT_Fibra de vidre rígida:...) | In | Length (m) | Group
1342100 | Nivell -01 PS1_PK | 8.275 | VEN_APT 6
1342164 | Nivell -01 PS1_PK | 5.08 | VEN_APT 8
1342230 | Nivell 00 P00_PB | 0.417015 | VEN_APT 8
1342239 | Nivell 00 P00_PB | 0.486015 | VEN_APT 8
1343837 | Nivell 06 P06_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1343843 | Nivell 06 P06_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1343854 | Nivell 06 P06_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1343889 | Nivell 06 P06_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1344350 | Nivell 01 P01_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344351 | Nivell 01 P01_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344352 | Nivell 01 P01_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344355 | Nivell 01 P01_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344390 | Nivell 02 P02_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344391 | Nivell 02 P02_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344392 | Nivell 02 P02_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344395 | Nivell 02 P02_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344430 | Nivell 03 P03_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344431 | Nivell 03 P03_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344432 | Nivell 03 P03_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344435 | Nivell 03 P03_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344470 | Nivell 04 P04_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344471 | Nivell 04 P04_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344472 | Nivell 04 P04_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344475 | Nivell 04 P04_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344510 | Nivell 05 P05_PP | 1.275 | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1344511 | Nivell 05 P05_PP | 1.075 | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1344512 | Nivell 05 P05_PP | 1.1 | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1344515 | Nivell 05 P05_PP | 0.8 | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1345351 | Nivell -01 PS1_PK | 3.17083 | VEN_APT 6
1345352 | Nivell -01 PS1_PK | 1.38995 | VEN_APT 6
1345838 | Nivell 00 P00_PB | 5.27051 | VEN_APT 7
1346009 | Nivell 00 P00_PB | 1.34353 | VEN_APT 11
1346011 | Nivell 00 P00_PB | 3.09289 | VEN_APT 11
1346014 | Nivell 00 P00_PB | 1.76961 | VEN_APT 11
1346016 | Nivell 00 P00_PB | 0.565851 | VEN_APT 11
1456212 | Nivell -01 PS1_PK | 1.762 | VEN_APT 6
1456359 | Nivell -01 PS1_PK | 0.674868 | VEN_APT 6
1456368 | Nivell -01 PS1_PK | 2.72928 | VEN_APT 6
1471528 | Nivell -01 PS1_PK | 6.61547 | VEN_APT 6
1472355 | Nivell -01 PS1_PK | 3.50528 | VEN_APT 6
1485137 | Nivell 00 P00_PB | 2.48823 | VEN_APT 8
1485217 | Nivell 00 P00_PB | 1.67266 | VEN_APT 8
1498744 | Nivell -01 PS1_PK | 0.857 | VEN_APT 6
1499836 | Nivell -01 PS1_PK | 1.64396 | VEN_APT 6
1500083 | Nivell -01 PS1_PK | 12.1394 | VEN_APT 6
1518107 | Nivell -01 PS1_PK | 5.46416 | VEN_APT 6
1518297 | Nivell -01 PS1_PK | 0.4 | VEN_APT 6
1523187 | Nivell -01 PS1_PK | 9.63135 | VEN_APT 6
1523235 | Nivell -01 PS1_PK | 0.724264 | VEN_APT 6
1523292 | Nivell -01 PS1_PK | 0.375 | VEN_APT 6

# IfcFlowSegment: Rectangular Duct:APT_Planxa galvanitzada (6)
In: Nivell 07 P07_PP
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: APT_Planxa galvanitzada; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:APT_Planxa galvanitzada:...) | Length (m) | Group
1339732 | 24.06 | VEN_APT 2
1339764 | 25.076 | VEN_EXT 2
1339829 | 21.7562 | VEN_APT 4
1339863 | 34.11 | VEN_APT 4
1340475 | 21.7563 | VEN_APT 1
1340476 | 34.11 | VEN_APT 1

# IfcFlowSegment: Rectangular Duct:EXT_Fibra de vidre rígida (46)
Type - Pset_ManufacturerTypeInformation - Manufacturer: ISOVER
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_Fibra de vidre rígida; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:EXT_Fibra de vidre rígida:...) | In | Length (m) | Group
1342295 | Nivell -01 PS1_PK | 8.275 | VEN_EXT 7
1342316 | Nivell -01 PS1_PK | 2.22268 | VEN_EXT 8
1342419 | Nivell -01 PS1_PK | 4.83 | VEN_EXT 8
1342503 | Nivell 00 P00_PB | 1.12619 | VEN_EXT 8
1342512 | Nivell 00 P00_PB | 2.33602 | VEN_EXT 8
1342557 | Nivell 00 P00_PB | 0.0500002 | VEN_EXT 8
1343976 | Nivell 06 P06_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1343978 | Nivell 06 P06_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1343981 | Nivell 06 P06_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1343983 | Nivell 06 P06_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1344356 | Nivell 01 P01_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344357 | Nivell 01 P01_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344359 | Nivell 01 P01_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344360 | Nivell 01 P01_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344396 | Nivell 02 P02_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344397 | Nivell 02 P02_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344399 | Nivell 02 P02_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344400 | Nivell 02 P02_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344436 | Nivell 03 P03_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344437 | Nivell 03 P03_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344439 | Nivell 03 P03_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344440 | Nivell 03 P03_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344476 | Nivell 04 P04_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344477 | Nivell 04 P04_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344479 | Nivell 04 P04_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344480 | Nivell 04 P04_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344516 | Nivell 05 P05_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1344517 | Nivell 05 P05_PP | 2.8 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1344519 | Nivell 05 P05_PP | 0.58 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1344520 | Nivell 05 P05_PP | 4.8 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1345485 | Nivell -01 PS1_PK | 1.38995 | VEN_EXT 7
1345491 | Nivell -01 PS1_PK | 2.62083 | VEN_EXT 7
1345803 | Nivell 00 P00_PB | 0.780826 | VEN_EXT 12
1345811 | Nivell 00 P00_PB | 4.52051 | VEN_EXT 12
1345927 | Nivell 00 P00_PB | 5.3 | VEN_EXT 14
1345933 | Nivell 00 P00_PB | 0.12 | VEN_EXT 14
1456417 | Nivell -01 PS1_PK | 1.90468 | VEN_EXT 7
1471531 | Nivell -01 PS1_PK | 4.91416 | VEN_EXT 7
1472407 | Nivell -01 PS1_PK | 2.31586 | VEN_EXT 7
1485110 | Nivell 00 P00_PB | 2.93822 | VEN_EXT 8
1498521 | Nivell -01 PS1_PK | 2.77459 | VEN_EXT 7
1499805 | Nivell -01 PS1_PK | 1.62955 | VEN_EXT 7
1500118 | Nivell -01 PS1_PK | 12.1394 | VEN_EXT 7
1518166 | Nivell -01 PS1_PK | 6.02016 | VEN_EXT 7
1518272 | Nivell -01 PS1_PK | 0.4 | VEN_EXT 7
1518848 | Nivell -01 PS1_PK | 0.1234 | VEN_EXT 7

# IfcFlowSegment: Rectangular Duct:EXT_Planxa galvanitzada (82)
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_Planxa galvanitzada; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:EXT_Planxa galvanitzada:...) | In | Length (m) | Group
1341672 | Nivell 07 P07_PP | 2.77322 | VEN_EXT 5
1341674 | Nivell 06 P06_PP | 1.73331 | VEN_EXT 5
1341677 | Nivell 06 P06_PP | 6.24991 | VEN_EXT 5
1343106 | Nivell 08 P08_PC | 1.43829 | VEN_APT 2
1343160 | Nivell 08 P08_PC | 0.0724917 | VEN_APT 4
1343168 | Nivell 07 P07_PP | 0.11378 | VEN_APT 4
1343183 | Nivell 07 P07_PP | 1.5 | VEN_APT 4
1343446 | Nivell 08 P08_PC | 0.0724916 | VEN_APT 1
1343447 | Nivell 07 P07_PP | 0.11378 | VEN_APT 1
1343448 | Nivell 07 P07_PP | 1.5 | VEN_APT 1
1440780 | Nivell 06 P06_PP | 0.146025 | VEN_EXT 5
1440787 | Nivell 06 P06_PP | 0.232034 | VEN_EXT 5
1444834 | Nivell 07 P07_PP | 2.64822 | VEN_EXT 3
1444835 | Nivell 06 P06_PP | 0.880283 | VEN_EXT 3
1444899 | Nivell 06 P06_PP | 5.80042 | VEN_EXT 3
1444974 | Nivell 06 P06_PP | 0.890288 | VEN_EXT 3
1468832 | Nivell 07 P07_PP | 0.16329 | VEN_EXT 2
1469076 | Nivell 07 P07_PP | 0.882946 | VEN_EXT 2
1471008 | Nivell -01 PS1_PK | 4.03216 | Model Group:05_CLI_FC01_PS1:1471264; CLI_IMP 1
1471144 | Nivell -01 PS1_PK | 0.58 | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1471211 | Nivell -01 PS1_PK | 5.3 | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1471220 | Nivell -01 PS1_PK | 0.995871 | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1472863 | Nivell 00 P00_PB | 6.12483 | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_IMP 4
1473335 | Nivell 00 P00_PB | 0.6 | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_RET 4
1474809 | Nivell 00 P00_PB | 7.65197 | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_RET 4
1474817 | Nivell 00 P00_PB | 0.0714887 | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_RET 4
1474868 | Nivell 00 P00_PB | 0.175175 | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_IMP 4
1475892 | Nivell -01 PS1_PK | 4.03216 | Model Group:05_CLI_FC01_PS1:1475899; CLI_IMP 2
1475893 | Nivell -01 PS1_PK | 0.58 | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475895 | Nivell -01 PS1_PK | 5.3 | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475896 | Nivell -01 PS1_PK | 0.995871 | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475918 | Nivell -01 PS1_PK | 4.03216 | Model Group:05_CLI_FC01_PS1:1475925; CLI_IMP 3
1475919 | Nivell -01 PS1_PK | 0.58 | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3
1475921 | Nivell -01 PS1_PK | 5.3 | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3
1475922 | Nivell -01 PS1_PK | 0.995871 | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3
1480227 | Nivell 06 P06_PP | 0.15 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1480228 | Nivell 06 P06_PP | 0.3 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1480231 | Nivell 06 P06_PP | 0.114819 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1480497 | Nivell 06 P06_PP | 0.24467 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1480545 | Nivell 06 P06_PP | 0.950069 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1480579 | Nivell 06 P06_PP | 1.225 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1480613 | Nivell 06 P06_PP | 0.95 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1480644 | Nivell 06 P06_PP | 1.22507 | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1480782 | Nivell 04 P04_PP | 0.841596 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_IMP 5
1480786 | Nivell 04 P04_PP | 0.530665 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1480788 | Nivell 04 P04_PP | 1.02496 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1480790 | Nivell 04 P04_PP | 1.3001 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1480791 | Nivell 04 P04_PP | 1.025 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_IMP 5
1480793 | Nivell 04 P04_PP | 1.30007 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_IMP 5
1480928 | Nivell 04 P04_PP | 0.193266 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1480986 | Nivell 01 P01_PP | 0.841596 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_IMP 6
1480987 | Nivell 01 P01_PP | 0.530665 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1480988 | Nivell 01 P01_PP | 1.02496 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1480990 | Nivell 01 P01_PP | 1.3001 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1480991 | Nivell 01 P01_PP | 1.025 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_IMP 6
1480993 | Nivell 01 P01_PP | 1.30007 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_IMP 6
1480995 | Nivell 01 P01_PP | 0.193266 | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1481006 | Nivell 02 P02_PP | 0.841596 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_IMP 10
1481007 | Nivell 02 P02_PP | 0.530665 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481008 | Nivell 02 P02_PP | 1.02496 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481010 | Nivell 02 P02_PP | 1.3001 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481011 | Nivell 02 P02_PP | 1.025 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_IMP 10
1481013 | Nivell 02 P02_PP | 1.30007 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_IMP 10
1481015 | Nivell 02 P02_PP | 0.193266 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481026 | Nivell 03 P03_PP | 0.841596 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_IMP 13
1481027 | Nivell 03 P03_PP | 0.530665 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481028 | Nivell 03 P03_PP | 1.02496 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481030 | Nivell 03 P03_PP | 1.3001 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481031 | Nivell 03 P03_PP | 1.025 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_IMP 13
1481033 | Nivell 03 P03_PP | 1.30007 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_IMP 13
1481035 | Nivell 03 P03_PP | 0.193266 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481046 | Nivell 05 P05_PP | 0.841596 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_IMP 16
1481047 | Nivell 05 P05_PP | 0.530665 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1481048 | Nivell 05 P05_PP | 1.02496 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1481050 | Nivell 05 P05_PP | 1.3001 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1481051 | Nivell 05 P05_PP | 1.025 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_IMP 16
1481053 | Nivell 05 P05_PP | 1.30007 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_IMP 16
1481055 | Nivell 05 P05_PP | 0.193266 | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1592912 | Nivell 07 P07_PP | 1.45 | VEN_EXT 4
1592920 | Nivell 07 P07_PP | 1.67533 | VEN_EXT 4
1592995 | Nivell 07 P07_PP | 1.45 | VEN_EXT 24
1592996 | Nivell 07 P07_PP | 1.67533 | VEN_EXT 24

# IfcFlowSegment: Rectangular Duct:IMP_Fibra de vidre rígida (16)
In: Nivell 00 P00_PB
Type - Pset_ManufacturerTypeInformation - Manufacturer: ISOVER
Classification: 50.30.40.30 Impulsió de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: IMP_Fibra de vidre rígida; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:IMP_Fibra de vidre rígida:...) | Length (m) | Group
1586500 | 6.39 | CLI_RET 8
1587320 | 1.42 | CLI_RET 7
1587322 | 1.44739 | CLI_RET 7
1587323 | 7.33183 | CLI_RET 7
1587690 | 0.86 | CLI_IMP 11
1587997 | 0.309051 | CLI_IMP 11
1588225 | 4.83523 | CLI_IMP 11
1588226 | 0.208517 | CLI_IMP 11
1588366 | 0.1 | CLI_RET 8
1588378 | 1.51 | CLI_RET 8
1588611 | 6.39 | CLI_IMP 7
1588612 | 0.1 | CLI_IMP 7
1588614 | 0.96 | CLI_IMP 7
1588628 | 6.39 | CLI_RET 12
1588629 | 0.1 | CLI_RET 12
1588631 | 1.51 | CLI_RET 12

# IfcFlowSegment: Round Duct:EXT_Acer Galvanitzat - Rígid (223)
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_Acer Galvanitzat - Rígid; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:EXT_Acer Galvanitzat - Rígid:...) | In | Length (m) | Group
1339786 | Nivell 07 P07_PP | 24.9437 | VEN_EXT 1
1340630 | Nivell 06 P06_PP | 21.4189 | VEN_EXT 3
1340915 | Nivell 07 P07_PP | 3.93 | VEN_EXT 16
1340968 | Nivell 00 P00_PB | 1.36384 | VEN_EXT 16
1341183 | Nivell 00 P00_PB | 0.841934 | VEN_EXT 16
1341243 | Nivell 06 P06_PP | 0.0925 | VEN_EXT 16
1341354 | Nivell 00 P00_PB | 0.014256 | VEN_EXT 16
1341679 | Nivell 06 P06_PP | 3.14539 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1341709 | Nivell -01 PS1_PK | 29.2103 | VEN_EXT 6
1341765 | Nivell -01 PS1_PK | 10.8778 | VEN_EXT 6
1341774 | Nivell -01 PS1_PK | 2.49303 | VEN_EXT 6
1341835 | Nivell -01 PS1_PK | 3.92 | VEN_EXT 6
1341970 | Nivell -01 PS1_PK | 4.60032 | VEN_EXT 6
1341980 | Nivell -01 PS1_PK | 2.20086 | VEN_EXT 6
1342000 | Nivell -01 PS1_PK | 1.35 | VEN_EXT 6
1342058 | Nivell -01 PS1_PK | 3.325 | VEN_EXT 6
1343998 | Nivell 06 P06_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344007 | Nivell 06 P06_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344018 | Nivell 06 P06_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344041 | Nivell 06 P06_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344058 | Nivell 06 P06_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344363 | Nivell 01 P01_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344365 | Nivell 01 P01_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344369 | Nivell 01 P01_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344375 | Nivell 01 P01_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344377 | Nivell 01 P01_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344403 | Nivell 02 P02_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344405 | Nivell 02 P02_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344409 | Nivell 02 P02_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344415 | Nivell 02 P02_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344417 | Nivell 02 P02_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344443 | Nivell 03 P03_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344445 | Nivell 03 P03_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344449 | Nivell 03 P03_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344455 | Nivell 03 P03_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344457 | Nivell 03 P03_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344483 | Nivell 04 P04_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344485 | Nivell 04 P04_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344489 | Nivell 04 P04_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344495 | Nivell 04 P04_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344497 | Nivell 04 P04_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344523 | Nivell 05 P05_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344525 | Nivell 05 P05_PP | 1.95 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344529 | Nivell 05 P05_PP | 3.7 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344535 | Nivell 05 P05_PP | 2.45 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344537 | Nivell 05 P05_PP | 0.25 | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1394320 | Nivell 00 P00_PB | 1.54219 | VEN_EXT 16
1394408 | Nivell 00 P00_PB | 0.208579 | VEN_EXT 16
1437544 | Nivell 05 P05_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1437605 | Nivell 05 P05_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 40
1437612 | Nivell 05 P05_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 40
1438674 | Nivell 05 P05_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 40
1438984 | Nivell 05 P05_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1438988 | Nivell 05 P05_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439003 | Nivell 05 P05_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439007 | Nivell 05 P05_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439343 | Nivell 05 P05_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439345 | Nivell 05 P05_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 41
1439347 | Nivell 05 P05_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 41
1439352 | Nivell 05 P05_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 41
1439354 | Nivell 05 P05_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439356 | Nivell 05 P05_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439358 | Nivell 05 P05_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439362 | Nivell 05 P05_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439663 | Nivell 04 P04_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439665 | Nivell 04 P04_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 44
1439667 | Nivell 04 P04_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 44
1439672 | Nivell 04 P04_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 44
1439674 | Nivell 04 P04_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439676 | Nivell 04 P04_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439678 | Nivell 04 P04_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439682 | Nivell 04 P04_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439701 | Nivell 06 P06_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439703 | Nivell 06 P06_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 45
1439705 | Nivell 06 P06_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 45
1439710 | Nivell 06 P06_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 45
1439712 | Nivell 06 P06_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
