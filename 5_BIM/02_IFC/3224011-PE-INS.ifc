Properties of the parts of a building model (IFC2X3), part 11 of 11

# IfcFlowSegment: Round Duct:EXT_Acer Galvanitzat - Rígid (223)
Name (Round Duct:EXT_Acer Galvanitzat - Rígid:...) | In | Length (m) | Group
1439714 | Nivell 06 P06_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439716 | Nivell 06 P06_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439720 | Nivell 06 P06_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439896 | Nivell 04 P04_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439898 | Nivell 04 P04_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 46
1439900 | Nivell 04 P04_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 46
1439905 | Nivell 04 P04_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 46
1439907 | Nivell 04 P04_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439909 | Nivell 04 P04_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439911 | Nivell 04 P04_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439915 | Nivell 04 P04_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439934 | Nivell 06 P06_PP | 7.17751 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439936 | Nivell 06 P06_PP | 0.9 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 48
1439938 | Nivell 06 P06_PP | 1.69755 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 48
1439943 | Nivell 06 P06_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 48
1439945 | Nivell 06 P06_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439947 | Nivell 06 P06_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439949 | Nivell 06 P06_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439953 | Nivell 06 P06_PP | 0.145 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1446435 | Nivell 01 P01_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446436 | Nivell 01 P01_PP | 0.9 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446438 | Nivell 01 P01_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446442 | Nivell 01 P01_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446444 | Nivell 01 P01_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446445 | Nivell 01 P01_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446446 | Nivell 01 P01_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446450 | Nivell 01 P01_PP | 0.17 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446472 | Nivell 02 P02_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446473 | Nivell 02 P02_PP | 0.9 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446475 | Nivell 02 P02_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446479 | Nivell 02 P02_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446481 | Nivell 02 P02_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446482 | Nivell 02 P02_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446483 | Nivell 02 P02_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446487 | Nivell 02 P02_PP | 0.17 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446861 | Nivell 01 P01_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446862 | Nivell 01 P01_PP | 0.9 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446864 | Nivell 01 P01_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446868 | Nivell 01 P01_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446870 | Nivell 01 P01_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446871 | Nivell 01 P01_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446872 | Nivell 01 P01_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446876 | Nivell 01 P01_PP | 0.17 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446893 | Nivell 02 P02_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446894 | Nivell 02 P02_PP | 0.9 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446896 | Nivell 02 P02_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446900 | Nivell 02 P02_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446902 | Nivell 02 P02_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446903 | Nivell 02 P02_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446904 | Nivell 02 P02_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446908 | Nivell 02 P02_PP | 0.17 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1447371 | Nivell 01 P01_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1447388 | Nivell 02 P02_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1447441 | Nivell 01 P01_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1447458 | Nivell 02 P02_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1449402 | Nivell 01 P01_PP | 6.1 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1449790 | Nivell 02 P02_PP | 6.1 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1449834 | Nivell 01 P01_PP | 6.1 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1449856 | Nivell 02 P02_PP | 6.1 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1453488 | Nivell 06 P06_PP | 17.7914 | VEN_EXT 5
1453825 | Nivell 00 P00_PB | 0.237868 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1453888 | Nivell 00 P00_PB | 5.57211 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454032 | Nivell 00 P00_PB | 0.328284 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454165 | Nivell 00 P00_PB | 0.624393 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454192 | Nivell 00 P00_PB | 0.02 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454806 | Nivell 00 P00_PB | 0.65 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1454899 | Nivell 00 P00_PB | 1.5 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1454908 | Nivell 00 P00_PB | 5.02864 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1454917 | Nivell 00 P00_PB | 0.749997 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455441 | Nivell 00 P00_PB | 0.05 | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455851 | Nivell -01 PS1_PK | 5.21452 | VEN_EXT 16
1455860 | Nivell -01 PS1_PK | 6.425 | VEN_EXT 16
1458472 | Nivell 05 P05_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458483 | Nivell 05 P05_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458870 | Nivell 05 P05_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458874 | Nivell 05 P05_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458888 | Nivell 04 P04_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458892 | Nivell 04 P04_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458906 | Nivell 06 P06_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458910 | Nivell 06 P06_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458924 | Nivell 04 P04_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458928 | Nivell 04 P04_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458942 | Nivell 06 P06_PP | 0.441423 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1458946 | Nivell 06 P06_PP | 1.09787 | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1459047 | Nivell 02 P02_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459064 | Nivell 02 P02_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459293 | Nivell 01 P01_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459297 | Nivell 01 P01_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459309 | Nivell 02 P02_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459313 | Nivell 02 P02_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459341 | Nivell 01 P01_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1459345 | Nivell 01 P01_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1474547 | Nivell -01 PS1_PK | 0.360589 | VEN_EXT 6
1474565 | Nivell -01 PS1_PK | 7.89605 | VEN_EXT 6
1474580 | Nivell -01 PS1_PK | 0.360589 | VEN_EXT 6
1474593 | Nivell -01 PS1_PK | 2.56103 | VEN_EXT 6
1476633 | Nivell 03 P03_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476634 | Nivell 03 P03_PP | 0.9 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476635 | Nivell 03 P03_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476638 | Nivell 03 P03_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476639 | Nivell 03 P03_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476640 | Nivell 03 P03_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476641 | Nivell 03 P03_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476643 | Nivell 03 P03_PP | 0.17 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476650 | Nivell 03 P03_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476652 | Nivell 03 P03_PP | 1.97258 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476656 | Nivell 03 P03_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476658 | Nivell 03 P03_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476660 | Nivell 03 P03_PP | 0.0585786 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476662 | Nivell 03 P03_PP | 3.94458 | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476796 | Nivell 03 P03_PP | 7.11645 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476797 | Nivell 03 P03_PP | 0.9 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476798 | Nivell 03 P03_PP | 1.70149 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476801 | Nivell 03 P03_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476802 | Nivell 03 P03_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476803 | Nivell 03 P03_PP | 0.0684 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476804 | Nivell 03 P03_PP | 1.30149 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476806 | Nivell 03 P03_PP | 0.17 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476813 | Nivell 03 P03_PP | 0.1484 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476815 | Nivell 03 P03_PP | 1.97258 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476819 | Nivell 03 P03_PP | 0.400003 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476821 | Nivell 03 P03_PP | 1.05716 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476823 | Nivell 03 P03_PP | 0.0585786 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476825 | Nivell 03 P03_PP | 3.94458 | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1487290 | Nivell 00 P00_PB | 0.938233 | VEN_EXT 16
1487291 | Nivell 00 P00_PB | 0.208579 | VEN_EXT 16
1499364 | Nivell -01 PS1_PK | 1.35251 | VEN_EXT 16
1499485 | Nivell -01 PS1_PK | 0.0353553 | VEN_EXT 16
1516338 | Nivell -01 PS1_PK | 5.73563 | VEN_EXT 6
1541357 | Nivell -01 PS1_PK | 0.0571255 | VEN_EXT 6
1541374 | Nivell -01 PS1_PK | 4.24474 | VEN_EXT 6
1543306 | Nivell -01 PS1_PK | 2.42182 | VEN_EXT 6
1543314 | Nivell -01 PS1_PK | 17.619 | VEN_EXT 6
1543325 | Nivell -01 PS1_PK | 2.175 | VEN_EXT 6
1551809 | Nivell -01 PS1_PK | 8.59228 | VEN_EXT 6
1551884 | Nivell -01 PS1_PK | 0.496656 | VEN_EXT 6
1557807 | Nivell -01 PS1_PK | 1.45 | VEN_EXT 6
1557902 | Nivell -01 PS1_PK | 0.455 | VEN_EXT 6
1576069 | Nivell -01 PS1_PK | 1.76551 | VEN_EXT 6
1576216 | Nivell -01 PS1_PK | 5.28807 | VEN_EXT 6
1579727 | Nivell -01 PS1_PK | 0.25648 | VEN_EXT 6
1579743 | Nivell -01 PS1_PK | 0.926602 | VEN_EXT 6
1579762 | Nivell -01 PS1_PK | 0.4734 | VEN_EXT 6
1593011 | Nivell 07 P07_PP | 1.06447 | VEN_EXT 1
1593082 | Nivell 07 P07_PP | 1.95 | VEN_EXT 35
1593101 | Nivell 07 P07_PP | 3.35 | VEN_EXT 35

# IfcFlowTerminal: ARC_PF_desaigua coberta:Diámetro salida 70mm (20)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Diámetro salida 70mm; sets with these values: 2
Name (ARC_PF_desaigua coberta:Diámetro salida 70mm:...) | In | Group
1338579 | Nivell 08 P08_PC | 04_SN_APLU 1
1338609 | Nivell 08 P08_PC | 04_SN_APLU 2
1338614 | Nivell 08 P08_PC | 04_SN_APLU 3
1346656 | Nivell 07 P07_PP | 04_SN_APLU 11
1347434 | Nivell 08 P08_PC | 04_SN_APLU 3
1347447 | Nivell 08 P08_PC | 04_SN_APLU 3
1347460 | Nivell 07 P07_PP | 04_SN_APLU 8
1347503 | Nivell 07 P07_PP | 04_SN_APLU 3
1347586 | Nivell 07 P07_PP | 04_SN_APLU 2
1350265 | Nivell 05 P05_PP | 04_SN_APLU 5
1350533 | Nivell 05 P05_PP | 04_SN_APLU 12
1350705 | Nivell 07 P07_PP | 04_SN_APLU 1
1352323 | Nivell 08 P08_PC | 04_SN_APLU 4
1352334 | Nivell 08 P08_PC | 04_SN_APLU 4
1352512 | Nivell 04 P04_PP | 04_SN_APLU 6
1352647 | Nivell 03 P03_PP | 04_SN_APLU 7
1352883 | Nivell 04 P04_PP | 04_SN_APLU 6
1353090 | Nivell 04 P04_PP | 04_SN_APLU 13
1353103 | Nivell 03 P03_PP | 04_SN_APLU 15
1353118 | Nivell 04 P04_PP | 04_SN_APLU 13
