Properties of the parts of a building model (IFC2X3), part 9 of 11

# IfcFlowSegment: Pipe Types:PPR_CLI_Aquatherm Blue Pipe (381)
Name (Pipe Types:PPR_CLI_Aquatherm Blue Pipe:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1386933 | Nivell 07 P07_PP | 3.355 | 36.6782 | 05_CA_AF_RET 4
1386935 | Nivell 07 P07_PP | 3.625 | 36.6782 | 05_CA_AF_IMP 4
1386937 | Nivell 07 P07_PP | 3.93706 | 36.76 | 05_CA_AC_RET 4
1386939 | Nivell 07 P07_PP | 4.13706 | 36.76 | 05_CA_AC_IMP 3
1386941 | Nivell 07 P07_PP | 0.395 | 36.6782 | 05_CA_AF_IMP 4
1386943 | Nivell 07 P07_PP | 0.707063 | 36.76 | 05_CA_AC_RET 4
1386945 | Nivell 07 P07_PP | 0.907063 | 36.76 | 05_CA_AC_IMP 3
1386947 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AF_RET 6
1386951 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AF_IMP 6
1386953 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AC_RET 6
1386955 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AC_IMP 6
1387023 | Nivell 06 P06_PP | 0.704563 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387032 | Nivell 06 P06_PP | 3.01996 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387099 | Nivell 06 P06_PP | 1.00456 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387102 | Nivell 06 P06_PP | 3.41996 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387110 | Nivell 06 P06_PP | 1.25456 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387113 | Nivell 06 P06_PP | 3.81996 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387121 | Nivell 06 P06_PP | 1.45456 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387124 | Nivell 06 P06_PP | 4.21996 | 32.8418 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387228 | Nivell 06 P06_PP | 2.11638 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387230 | Nivell 06 P06_PP | 2.01638 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387232 | Nivell 06 P06_PP | 1.96638 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387234 | Nivell 06 P06_PP | 1.96638 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387490 | Nivell 06 P06_PP | 9.09829 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387492 | Nivell 06 P06_PP | 9.49829 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387494 | Nivell 06 P06_PP | 9.89829 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387496 | Nivell 06 P06_PP | 10.2983 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387553 | Nivell 06 P06_PP | 1.2346 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387555 | Nivell 06 P06_PP | 1.6346 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387557 | Nivell 06 P06_PP | 2.0346 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387559 | Nivell 06 P06_PP | 2.4346 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387662 | Nivell 06 P06_PP | 0.665 | 32.9282 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 7
1387664 | Nivell 06 P06_PP | 3.355 | 32.9282 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 7
1387666 | Nivell 06 P06_PP | 3.625 | 32.9282 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 7
1387668 | Nivell 06 P06_PP | 3.93706 | 32.92 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 7
1387670 | Nivell 06 P06_PP | 4.13706 | 32.92 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 7
1387672 | Nivell 06 P06_PP | 0.965 | 32.9282 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 7
1387674 | Nivell 06 P06_PP | 1.32706 | 32.92 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 7
1387676 | Nivell 06 P06_PP | 1.52706 | 32.92 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 7
1389491 | Nivell 06 P06_PP | 0.0660625 | 32.9179 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389496 | Nivell 06 P06_PP | 8.45776 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389531 | Nivell 06 P06_PP | 0.0660625 | 32.9179 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389536 | Nivell 06 P06_PP | 8.95776 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389571 | Nivell 06 P06_PP | 0.0660625 | 32.9179 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389576 | Nivell 06 P06_PP | 9.40776 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389611 | Nivell 06 P06_PP | 0.0660625 | 32.9179 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1389616 | Nivell 06 P06_PP | 9.80776 | 32.9918 | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1389973 | Nivell 01 P01_PP | 0.704563 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1389975 | Nivell 01 P01_PP | 3.01996 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1389977 | Nivell 01 P01_PP | 1.00456 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1389979 | Nivell 01 P01_PP | 3.41996 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1389981 | Nivell 01 P01_PP | 1.25456 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1389983 | Nivell 01 P01_PP | 3.81996 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1389985 | Nivell 01 P01_PP | 1.45456 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1389987 | Nivell 01 P01_PP | 4.21996 | 14.0918 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1389989 | Nivell 01 P01_PP | 2.11638 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1389991 | Nivell 01 P01_PP | 2.01638 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1389993 | Nivell 01 P01_PP | 1.96638 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1389995 | Nivell 01 P01_PP | 1.96638 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1389997 | Nivell 01 P01_PP | 9.09829 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1389999 | Nivell 01 P01_PP | 9.49829 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390001 | Nivell 01 P01_PP | 9.89829 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390003 | Nivell 01 P01_PP | 10.2983 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390005 | Nivell 01 P01_PP | 1.2346 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390007 | Nivell 01 P01_PP | 1.6346 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390009 | Nivell 01 P01_PP | 2.0346 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390011 | Nivell 01 P01_PP | 2.4346 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390021 | Nivell 01 P01_PP | 0.665 | 14.1782 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 11
1390023 | Nivell 01 P01_PP | 3.355 | 14.1782 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 11
1390025 | Nivell 01 P01_PP | 3.625 | 14.1782 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 11
1390027 | Nivell 01 P01_PP | 3.93706 | 14.17 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 11
1390029 | Nivell 01 P01_PP | 4.13706 | 14.17 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 11
1390031 | Nivell 01 P01_PP | 0.965 | 14.1782 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 11
1390033 | Nivell 01 P01_PP | 1.32706 | 14.17 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 11
1390035 | Nivell 01 P01_PP | 1.52706 | 14.17 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 11
1390054 | Nivell 01 P01_PP | 0.0660625 | 14.1679 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390057 | Nivell 01 P01_PP | 8.45776 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390064 | Nivell 01 P01_PP | 0.0660625 | 14.1679 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390067 | Nivell 01 P01_PP | 8.95776 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390074 | Nivell 01 P01_PP | 0.0660625 | 14.1679 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390077 | Nivell 01 P01_PP | 9.40776 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390084 | Nivell 01 P01_PP | 0.0660625 | 14.1679 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390087 | Nivell 01 P01_PP | 9.80776 | 14.2418 | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390116 | Nivell 02 P02_PP | 0.704563 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390118 | Nivell 02 P02_PP | 3.01996 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390120 | Nivell 02 P02_PP | 1.00456 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390122 | Nivell 02 P02_PP | 3.41996 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390124 | Nivell 02 P02_PP | 1.25456 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390126 | Nivell 02 P02_PP | 3.81996 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390128 | Nivell 02 P02_PP | 1.45456 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390130 | Nivell 02 P02_PP | 4.21996 | 17.8418 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390132 | Nivell 02 P02_PP | 2.11638 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390134 | Nivell 02 P02_PP | 2.01638 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390136 | Nivell 02 P02_PP | 1.96638 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390138 | Nivell 02 P02_PP | 1.96638 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390140 | Nivell 02 P02_PP | 9.09829 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390142 | Nivell 02 P02_PP | 9.49829 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390144 | Nivell 02 P02_PP | 9.89829 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390146 | Nivell 02 P02_PP | 10.2983 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390148 | Nivell 02 P02_PP | 1.2346 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390150 | Nivell 02 P02_PP | 1.6346 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390152 | Nivell 02 P02_PP | 2.0346 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390154 | Nivell 02 P02_PP | 2.4346 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390164 | Nivell 02 P02_PP | 0.665 | 17.9282 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 16
1390166 | Nivell 02 P02_PP | 3.355 | 17.9282 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 16
1390168 | Nivell 02 P02_PP | 3.625 | 17.9282 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 16
1390170 | Nivell 02 P02_PP | 3.93706 | 17.92 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 17
1390172 | Nivell 02 P02_PP | 4.13706 | 17.92 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 16
1390174 | Nivell 02 P02_PP | 0.965 | 17.9282 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 16
1390176 | Nivell 02 P02_PP | 1.32706 | 17.92 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 17
1390178 | Nivell 02 P02_PP | 1.52706 | 17.92 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 16
1390197 | Nivell 02 P02_PP | 0.0660625 | 17.9179 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390200 | Nivell 02 P02_PP | 8.45776 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390207 | Nivell 02 P02_PP | 0.0660625 | 17.9179 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390210 | Nivell 02 P02_PP | 8.95776 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390217 | Nivell 02 P02_PP | 0.0660625 | 17.9179 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390220 | Nivell 02 P02_PP | 9.40776 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390227 | Nivell 02 P02_PP | 0.0660625 | 17.9179 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390230 | Nivell 02 P02_PP | 9.80776 | 17.9918 | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390259 | Nivell 03 P03_PP | 0.704563 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390261 | Nivell 03 P03_PP | 3.01996 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390263 | Nivell 03 P03_PP | 1.00456 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390265 | Nivell 03 P03_PP | 3.41996 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390267 | Nivell 03 P03_PP | 1.25456 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390269 | Nivell 03 P03_PP | 3.81996 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390271 | Nivell 03 P03_PP | 1.45456 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390273 | Nivell 03 P03_PP | 4.21996 | 21.5918 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390275 | Nivell 03 P03_PP | 2.11638 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390277 | Nivell 03 P03_PP | 2.01638 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390279 | Nivell 03 P03_PP | 1.96638 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390281 | Nivell 03 P03_PP | 1.96638 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390283 | Nivell 03 P03_PP | 9.09829 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390285 | Nivell 03 P03_PP | 9.49829 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390287 | Nivell 03 P03_PP | 9.89829 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390289 | Nivell 03 P03_PP | 10.2983 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390291 | Nivell 03 P03_PP | 1.2346 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390293 | Nivell 03 P03_PP | 1.6346 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390295 | Nivell 03 P03_PP | 2.0346 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390297 | Nivell 03 P03_PP | 2.4346 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390307 | Nivell 03 P03_PP | 0.665 | 21.6782 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 21
1390309 | Nivell 03 P03_PP | 3.355 | 21.6782 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 21
1390311 | Nivell 03 P03_PP | 3.625 | 21.6782 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 21
1390313 | Nivell 03 P03_PP | 3.93706 | 21.67 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 23
1390315 | Nivell 03 P03_PP | 4.13706 | 21.67 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 21
1390317 | Nivell 03 P03_PP | 0.965 | 21.6782 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 21
1390319 | Nivell 03 P03_PP | 1.32706 | 21.67 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 23
1390321 | Nivell 03 P03_PP | 1.52706 | 21.67 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 21
1390340 | Nivell 03 P03_PP | 0.0660625 | 21.6679 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390343 | Nivell 03 P03_PP | 8.45776 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390350 | Nivell 03 P03_PP | 0.0660625 | 21.6679 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390353 | Nivell 03 P03_PP | 8.95776 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390360 | Nivell 03 P03_PP | 0.0660625 | 21.6679 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390363 | Nivell 03 P03_PP | 9.40776 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390370 | Nivell 03 P03_PP | 0.0660625 | 21.6679 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390373 | Nivell 03 P03_PP | 9.80776 | 21.7418 | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390402 | Nivell 04 P04_PP | 0.704563 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390404 | Nivell 04 P04_PP | 3.01996 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390406 | Nivell 04 P04_PP | 1.00456 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390408 | Nivell 04 P04_PP | 3.41996 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390410 | Nivell 04 P04_PP | 1.25456 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390412 | Nivell 04 P04_PP | 3.81996 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390414 | Nivell 04 P04_PP | 1.45456 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390416 | Nivell 04 P04_PP | 4.21996 | 25.3418 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390418 | Nivell 04 P04_PP | 2.11638 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390420 | Nivell 04 P04_PP | 2.01638 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390422 | Nivell 04 P04_PP | 1.96638 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390424 | Nivell 04 P04_PP | 1.96638 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390426 | Nivell 04 P04_PP | 9.09829 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390428 | Nivell 04 P04_PP | 9.49829 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390430 | Nivell 04 P04_PP | 9.89829 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390432 | Nivell 04 P04_PP | 10.2983 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390434 | Nivell 04 P04_PP | 1.2346 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390436 | Nivell 04 P04_PP | 1.6346 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390438 | Nivell 04 P04_PP | 2.0346 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390440 | Nivell 04 P04_PP | 2.4346 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390450 | Nivell 04 P04_PP | 0.665 | 25.4282 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 26
1390452 | Nivell 04 P04_PP | 3.355 | 25.4282 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 26
1390454 | Nivell 04 P04_PP | 3.625 | 25.4282 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 26
1390456 | Nivell 04 P04_PP | 3.93706 | 25.42 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 29
1390458 | Nivell 04 P04_PP | 4.13706 | 25.42 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 26
1390460 | Nivell 04 P04_PP | 0.965 | 25.4282 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 26
1390462 | Nivell 04 P04_PP | 1.32706 | 25.42 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 29
1390464 | Nivell 04 P04_PP | 1.52706 | 25.42 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 26
1390483 | Nivell 04 P04_PP | 0.0660625 | 25.4179 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390486 | Nivell 04 P04_PP | 8.45776 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390493 | Nivell 04 P04_PP | 0.0660625 | 25.4179 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390496 | Nivell 04 P04_PP | 8.95776 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390503 | Nivell 04 P04_PP | 0.0660625 | 25.4179 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390506 | Nivell 04 P04_PP | 9.40776 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390513 | Nivell 04 P04_PP | 0.0660625 | 25.4179 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390516 | Nivell 04 P04_PP | 9.80776 | 25.4918 | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390545 | Nivell 05 P05_PP | 0.704563 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390547 | Nivell 05 P05_PP | 3.01996 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390549 | Nivell 05 P05_PP | 1.00456 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390551 | Nivell 05 P05_PP | 3.41996 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390553 | Nivell 05 P05_PP | 1.25456 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390555 | Nivell 05 P05_PP | 3.81996 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390557 | Nivell 05 P05_PP | 1.45456 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390559 | Nivell 05 P05_PP | 4.21996 | 29.0918 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390561 | Nivell 05 P05_PP | 2.11638 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390563 | Nivell 05 P05_PP | 2.01638 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390565 | Nivell 05 P05_PP | 1.96638 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390567 | Nivell 05 P05_PP | 1.96638 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390569 | Nivell 05 P05_PP | 9.09829 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390571 | Nivell 05 P05_PP | 9.49829 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390573 | Nivell 05 P05_PP | 9.89829 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390575 | Nivell 05 P05_PP | 10.2983 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390577 | Nivell 05 P05_PP | 1.2346 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390579 | Nivell 05 P05_PP | 1.6346 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390581 | Nivell 05 P05_PP | 2.0346 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390583 | Nivell 05 P05_PP | 2.4346 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390593 | Nivell 05 P05_PP | 0.665 | 29.1782 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 31
1390595 | Nivell 05 P05_PP | 3.355 | 29.1782 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 31
1390597 | Nivell 05 P05_PP | 3.625 | 29.1782 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 31
1390599 | Nivell 05 P05_PP | 3.93706 | 29.17 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 35
1390601 | Nivell 05 P05_PP | 4.13706 | 29.17 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 31
1390603 | Nivell 05 P05_PP | 0.965 | 29.1782 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 31
1390605 | Nivell 05 P05_PP | 1.32706 | 29.17 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 35
1390607 | Nivell 05 P05_PP | 1.52706 | 29.17 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 31
1390626 | Nivell 05 P05_PP | 0.0660625 | 29.1679 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390629 | Nivell 05 P05_PP | 8.45776 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390636 | Nivell 05 P05_PP | 0.0660625 | 29.1679 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390639 | Nivell 05 P05_PP | 8.95776 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390646 | Nivell 05 P05_PP | 0.0660625 | 29.1679 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390649 | Nivell 05 P05_PP | 9.40776 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390656 | Nivell 05 P05_PP | 0.0660625 | 29.1679 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390659 | Nivell 05 P05_PP | 9.80776 | 29.2418 | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1394846 | Nivell 00 P00_PB | 2.72695 | 10.5437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1394848 | Nivell 00 P00_PB | 1.44 | 10.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1394850 | Nivell 00 P00_PB | 3.14741 | 10.5437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1394852 | Nivell 00 P00_PB | 1.635 | 10.801 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1394854 | Nivell 00 P00_PB | 3.51039 | 10.5585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1394856 | Nivell 00 P00_PB | 1.835 | 10.801 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1394858 | Nivell 00 P00_PB | 3.85995 | 10.5585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1394868 | Nivell 00 P00_PB | 9.18492 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1394870 | Nivell 00 P00_PB | 9.53538 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1394872 | Nivell 00 P00_PB | 9.59847 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1394874 | Nivell 00 P00_PB | 9.94802 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1394876 | Nivell 00 P00_PB | 7.14533 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1394878 | Nivell 00 P00_PB | 7.14531 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1394880 | Nivell 00 P00_PB | 7.158 | 10.5585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1394882 | Nivell 00 P00_PB | 7.15799 | 10.5585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1395348 | Nivell 00 P00_PB | 1.28 | 10.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1395582 | Nivell 00 P00_PB | 12.8768 | 10.801 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1395837 | Nivell 00 P00_PB | 0.206862 | 10.5881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1395846 | Nivell 00 P00_PB | 0.206862 | 10.5881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1395855 | Nivell 00 P00_PB | 0.203012 | 10.587 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1395864 | Nivell 00 P00_PB | 0.203012 | 10.587 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1398448 | Nivell -01 PS1_PK | 1.09649 | 4.7382 | 05_CA_AF_RET 9
1398450 | Nivell -01 PS1_PK | 2.08504 | 5.7682 | 05_CA_AF_IMP 12
1398452 | Nivell -01 PS1_PK | 1.11655 | 4.7382 | 05_CA_AF_IMP 12
1398454 | Nivell -01 PS1_PK | 1.23707 | 5.805 | 05_CA_AC_RET 12
1398456 | Nivell -01 PS1_PK | 2.22098 | 4.81 | 05_CA_AC_RET 12
1398458 | Nivell -01 PS1_PK | 1.53707 | 5.805 | 05_CA_AC_IMP 12
1398460 | Nivell -01 PS1_PK | 2.221 | 4.81 | 05_CA_AC_IMP 12
1398528 | Nivell -01 PS1_PK | 1.72505 | 5.7682 | 05_CA_AF_RET 9
1398644 | Nivell -01 PS1_PK | 16.3288 | 4.7382 | 05_CA_AF_RET 9
1398646 | Nivell -01 PS1_PK | 15.6588 | 4.7382 | 05_CA_AF_IMP 12
1398648 | Nivell -01 PS1_PK | 16.6001 | 4.81 | 05_CA_AC_RET 12
1398650 | Nivell -01 PS1_PK | 16.1001 | 4.81 | 05_CA_AC_IMP 12
1399619 | Nivell -01 PS1_PK | 1.55194 | 4.52271 | 05_CA_AF_RET 12
1399621 | Nivell -01 PS1_PK | 1.26204 | 4.52272 | 05_CA_AF_IMP 15
1399623 | Nivell -01 PS1_PK | 1.1756 | 4.65 | 05_CA_AC_RET 12
1399625 | Nivell -01 PS1_PK | 0.975589 | 4.65 | 05_CA_AC_IMP 12
1402563 | Nivell -01 PS1_PK | 0.68 | 4.995 | 05_CA_AF_RET 9
1402574 | Nivell -01 PS1_PK | 0.68 | 4.995 | 05_CA_AF_IMP 12
1402583 | Nivell -01 PS1_PK | 0.869125 | 4.91794 | 05_CA_AC_RET 12
1402592 | Nivell -01 PS1_PK | 0.869125 | 4.91794 | 05_CA_AC_IMP 12
1468191 | Nivell 00 P00_PB | 13.2768 | 10.801 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1468197 | Nivell 00 P00_PB | 0.203051 | 9.821 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1468221 | Nivell 00 P00_PB | 13.6554 | 10.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1468227 | Nivell 00 P00_PB | 0.394275 | 9.8137 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1468255 | Nivell 00 P00_PB | 14.0354 | 10.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1468261 | Nivell 00 P00_PB | 0.664278 | 9.8137 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1469324 | Nivell 00 P00_PB | 0.938725 | 9.85064 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1469333 | Nivell 00 P00_PB | 0.938725 | 9.85064 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1469344 | Nivell 00 P00_PB | 0.926025 | 9.85699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1469353 | Nivell 00 P00_PB | 0.926025 | 9.85699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1469766 | Nivell 00 P00_PB | 0.62514 | 9.8085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1469768 | Nivell 00 P00_PB | 0.455136 | 9.8085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1469770 | Nivell 00 P00_PB | 0.288781 | 9.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1469772 | Nivell 00 P00_PB | 0.138773 | 9.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1469797 | Nivell 00 P00_PB | 3.61947 | 10.2085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1469831 | Nivell 00 P00_PB | 3.95718 | 10.1937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1469864 | Nivell 00 P00_PB | 4.30766 | 10.1937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1470214 | Nivell 00 P00_PB | 3.26981 | 10.2085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1473087 | Nivell 00 P00_PB | 0.348544 | 9.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1473089 | Nivell 00 P00_PB | 0.148523 | 9.7937 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1473091 | Nivell 00 P00_PB | 0.254863 | 9.8085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1473093 | Nivell 00 P00_PB | 0.0548568 | 9.8085 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1473142 | Nivell 00 P00_PB | 0.708725 | 9.83814 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1473154 | Nivell 00 P00_PB | 0.708725 | 9.83814 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1473171 | Nivell 00 P00_PB | 0.496025 | 9.83699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1473186 | Nivell 00 P00_PB | 0.496025 | 9.83699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1487578 | Nivell 00 P00_PB | 9.82455 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1487605 | Nivell 00 P00_PB | 0.183175 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1487634 | Nivell 00 P00_PB | 10.5459 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1487648 | Nivell 00 P00_PB | 0.254499 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1489191 | Nivell 00 P00_PB | 0.158725 | 10.3881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1489205 | Nivell 00 P00_PB | 0.158725 | 10.3881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1492641 | Nivell 00 P00_PB | 0.146025 | 10.387 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1492655 | Nivell 00 P00_PB | 0.146011 | 10.387 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1492670 | Nivell 00 P00_PB | 0.158725 | 10.3881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1492684 | Nivell 00 P00_PB | 0.158725 | 10.3881 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494248 | Nivell 00 P00_PB | 0.103012 | 10.237 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494253 | Nivell 00 P00_PB | 0.15319 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494299 | Nivell 00 P00_PB | 0.103012 | 10.237 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494304 | Nivell 00 P00_PB | 10.1746 | 10.3437 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494353 | Nivell 00 P00_PB | 0.114362 | 10.2381 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494358 | Nivell 00 P00_PB | 0.224512 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494408 | Nivell 00 P00_PB | 0.114363 | 10.2381 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494413 | Nivell 00 P00_PB | 10.9159 | 10.3585 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494700 | Nivell 00 P00_PB | 0.346025 | 9.83699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494709 | Nivell 00 P00_PB | 0.346025 | 9.83699 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494718 | Nivell 00 P00_PB | 0.358725 | 9.83814 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494727 | Nivell 00 P00_PB | 0.358725 | 9.83814 | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1528697 | Nivell -01 PS1_PK | 1.55581 | 4.9846 | 05_CA_AF_RET 15
1528699 | Nivell -01 PS1_PK | 1.31503 | 5.7846 | 05_CA_AF_IMP 9
1528701 | Nivell -01 PS1_PK | 1.57591 | 4.9846 | 05_CA_AF_IMP 9
1528703 | Nivell -01 PS1_PK | 1.73688 | 5.805 | 05_CA_AC_RET 12
1528705 | Nivell -01 PS1_PK | 2.22032 | 4.75 | 05_CA_AC_RET 12
1528707 | Nivell -01 PS1_PK | 2.03688 | 5.805 | 05_CA_AC_IMP 12
1528709 | Nivell -01 PS1_PK | 2.22035 | 4.75 | 05_CA_AC_IMP 12
1528711 | Nivell -01 PS1_PK | 0.955031 | 5.7846 | 05_CA_AF_RET 15
1528713 | Nivell -01 PS1_PK | 17.1891 | 4.9846 | 05_CA_AF_RET 15
1528715 | Nivell -01 PS1_PK | 16.5192 | 4.9846 | 05_CA_AF_IMP 9
1528717 | Nivell -01 PS1_PK | 16.1001 | 4.75 | 05_CA_AC_RET 12
1528719 | Nivell -01 PS1_PK | 15.6001 | 4.75 | 05_CA_AC_IMP 12
1528725 | Nivell -01 PS1_PK | 0.510002 | 5.195 | 05_CA_AF_RET 15
1528731 | Nivell -01 PS1_PK | 0.51 | 5.195 | 05_CA_AF_IMP 9
1528737 | Nivell -01 PS1_PK | 0.929125 | 4.85794 | 05_CA_AC_RET 12
1528743 | Nivell -01 PS1_PK | 0.929125 | 4.85794 | 05_CA_AC_IMP 12
1530596 | Nivell -01 PS1_PK | 2.898 | 4.2977 | 05_CA_AF_RET 15
1530598 | Nivell -01 PS1_PK | 2.898 | 4.2977 | 05_CA_AF_IMP 9
1530600 | Nivell -01 PS1_PK | 18.1405 | 4.4 | 05_CA_AC_RET 12
1530602 | Nivell -01 PS1_PK | 17.7405 | 4.4 | 05_CA_AC_IMP 12
1561332 | Nivell -01 PS1_PK | 0.36 | 4.545 | 05_CA_AF_IMP 9
1561345 | Nivell -01 PS1_PK | 0.36 | 4.545 | 05_CA_AF_RET 15
1561356 | Nivell -01 PS1_PK | 0.224125 | 4.50794 | 05_CA_AC_IMP 12
1561365 | Nivell -01 PS1_PK | 0.224125 | 4.50794 | 05_CA_AC_RET 12
1567974 | Nivell -01 PS1_PK | 0.135 | 4.51 | 05_CA_AF_IMP 12
1567987 | Nivell -01 PS1_PK | 0.135 | 4.51 | 05_CA_AF_RET 9
1568000 | Nivell -01 PS1_PK | 0.291063 | 4.501 | 05_CA_AC_IMP 12
1568013 | Nivell -01 PS1_PK | 0.291063 | 4.501 | 05_CA_AC_RET 12
1575866 | Nivell -01 PS1_PK | 1.48014 | 4.4 | 05_CA_AC_RET 12
1575893 | Nivell -01 PS1_PK | 1.68014 | 4.4 | 05_CA_AC_IMP 12
1577125 | Nivell -01 PS1_PK | 11.1948 | 4.5477 | 05_CA_AF_RET 12
1577127 | Nivell -01 PS1_PK | 10.8448 | 4.5477 | 05_CA_AF_IMP 15
1577129 | Nivell -01 PS1_PK | 10.7019 | 4.65 | 05_CA_AC_RET 12
1577131 | Nivell -01 PS1_PK | 10.5019 | 4.65 | 05_CA_AC_IMP 12
1577694 | Nivell -01 PS1_PK | 0.187791 | 4.4 | 05_CA_AC_IMP 12
1577738 | Nivell -01 PS1_PK | 0.187791 | 4.4 | 05_CA_AC_RET 12
1577866 | Nivell -01 PS1_PK | 0.124125 | 4.50794 | 05_CA_AC_IMP 12
1577877 | Nivell -01 PS1_PK | 0.124125 | 4.50794 | 05_CA_AC_RET 12
1595587 | Nivell -01 PS1_PK | 16.6116 | 4.3346 | 05_CA_AF_IMP 9
1595615 | Nivell -01 PS1_PK | 16.8615 | 4.3346 | 05_CA_AF_RET 15

# IfcFlowSegment: Pipe Types:PP_FN (150)
Classification: 50.10.20.30 Canalitzacions d'aigua sanitària (Uniformat)
Pset_DistributionFlowElementCommon - Reference: PP_FN; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:PP_FN:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1404062 | Nivell 06 P06_PP | 27.7753 | 5.74739 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 7
1404936 | Nivell 06 P06_PP | 27.7828 | 5.73989 | 03_FN_AFS 8
1411787 | Nivell -01 PS1_PK | 2.94761 | 4.6632 | 03_FN_AFS 1
1411796 | Nivell -01 PS1_PK | 0.200225 | 4.75239 | 03_FN_AFS 1
1411816 | Nivell -01 PS1_PK | 2.54761 | 4.5182 | 03_FN_AFS 1
1412660 | Nivell -01 PS1_PK | 0.439049 | 4.4864 | 03_FN_AFS 4
1412662 | Nivell -01 PS1_PK | 0.556049 | 4.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1412779 | Nivell 07 P07_PP | 30.59 | 5.91 | 03_FN_AFS 5
1412781 | Nivell 07 P07_PP | 30.59 | 5.91 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 4
1413183 | Nivell -01 PS1_PK | 0.32783 | 4.4864 | 03_FN_AFS 4
1413185 | Nivell -01 PS1_PK | 0.586329 | 4.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1413743 | Nivell -01 PS1_PK | 0.172775 | 4.61429 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1413746 | Nivell -01 PS1_PK | 2.34045 | 4.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1414912 | Nivell -01 PS1_PK | 11.9752 | 4.6632 | 03_FN_AFS 1
1415160 | Nivell -01 PS1_PK | 15.4903 | 4.9682 | 03_FN_AFS 1
1415268 | Nivell -01 PS1_PK | 13.7322 | 4.7364 | 03_FN_AFS 4
1415361 | Nivell -01 PS1_PK | 15.5957 | 4.95 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1416045 | Nivell -01 PS1_PK | 0.458042 | 4.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1416072 | Nivell -01 PS1_PK | 3.14761 | 4.5182 | 17_XRX_1ria_REG 1
1416094 | Nivell -01 PS1_PK | 0.645187 | 4.7682 | 17_XRX_1ria_REG 3
1416114 | Nivell -01 PS1_PK | 31.6426 | 4.85739 | 17_XRX_1ria_REG 3
1416330 | Nivell -01 PS1_PK | 0.648875 | 4.9932 | 17_XRX_1ria_REG 3
1416332 | Nivell -01 PS1_PK | 31.4176 | 5.08239 | 17_XRX_1ria_REG 3
1416962 | Nivell -01 PS1_PK | 0.536106 | 4.9789 | 03_FN_AFS 4
1416964 | Nivell -01 PS1_PK | 0.761606 | 4.985 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1416966 | Nivell -01 PS1_PK | 0.993256 | 4.9932 | 17_XRX_1ria_REG 3
1417000 | Nivell -01 PS1_PK | 0.979372 | 5.85 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1417002 | Nivell -01 PS1_PK | 6.78127 | 5.8682 | 17_XRX_1ria_REG 3
1417225 | Nivell -01 PS1_PK | 18.3949 | 5.8364 | 03_FN_AFS 4
1417227 | Nivell -01 PS1_PK | 18.4569 | 5.85 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1417229 | Nivell -01 PS1_PK | 15.7528 | 5.8682 | 17_XRX_1ria_REG 3
1417311 | Nivell -01 PS1_PK | 2.21023 | 59.0551 | 03_FN_AFS 4
1417313 | Nivell -01 PS1_PK | 2.62669 | 5.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1417395 | Nivell -01 PS1_PK | 0.122651 | 59.0551 | 03_FN_AFS 4
1417460 | Nivell -01 PS1_PK | 0.598256 | 5.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1417590 | Nivell -01 PS1_PK | 0.0563812 | 5.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1418299 | Nivell -01 PS1_PK | 5.64419 | 5.8364 | 03_FN_AFS 4
1419490 | Nivell -01 PS1_PK | 0.532604 | 4.18346 | 03_FN_AFS 4
1419503 | Nivell -01 PS1_PK | 0.547604 | 4.18446 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1419514 | Nivell -01 PS1_PK | 0.566705 | 4.18591 | 17_XRX_1ria_REG 3
1419999 | Nivell -01 PS1_PK | 0.898798 | 6.3082 | 17_XRX_1ria_REG 3
1420001 | Nivell -01 PS1_PK | 17.657 | 6.39739 | 17_XRX_1ria_REG 3
1420005 | Nivell -01 PS1_PK | 3.39886 | 5.6682 | 17_XRX_1ria_REG 3
1420007 | Nivell -01 PS1_PK | 18.297 | 5.75739 | 17_XRX_1ria_REG 3
1420123 | Nivell 06 P06_PP | 4.92 | 5.605 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 3
1420125 | Nivell 06 P06_PP | 4.92 | 5.605 | 03_FN_AFS 3
1420149 | Nivell -01 PS1_PK | 0.402062 | 6.31 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1420158 | Nivell -01 PS1_PK | 2.99233 | 6.31 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1420198 | Nivell -01 PS1_PK | 0.638562 | 6.3114 | 03_FN_AFS 4
1420203 | Nivell -01 PS1_PK | 2.92032 | 6.3114 | 03_FN_AFS 4
1420356 | Nivell -01 PS1_PK | 0.088875 | 5.75739 | 17_XRX_1ria_REG 3
1420359 | Nivell -01 PS1_PK | 1.93395 | 5.8682 | 17_XRX_1ria_REG 3
1420506 | Nivell 00 P00_PB | 0.0626125 | 10.4882 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 5
1420508 | Nivell 00 P00_PB | 0.307613 | 10.4882 | 03_FN_AFS 6
1420527 | Nivell 00 P00_PB | 2.46018 | 10.4882 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 5
1420563 | Nivell 00 P00_PB | 2.85018 | 10.4882 | 03_FN_AFS 6
1420970 | Nivell 00 P00_PB | 3.45918 | 10.4882 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 5
1420972 | Nivell 00 P00_PB | 3.70418 | 10.4882 | 03_FN_AFS 6
1423062 | Nivell -01 PS1_PK | 3.291 | 4.6364 | 03_FN_AFS 4
1423121 | Nivell -01 PS1_PK | 3.25497 | 4.9788 | 03_FN_AFS 4
1423164 | Nivell -01 PS1_PK | 3.37883 | 4.65 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1423174 | Nivell -01 PS1_PK | 2.12927 | 4.6364 | 03_FN_AFS 4
1423701 | Nivell -01 PS1_PK | 3.48981 | 4.6682 | 17_XRX_1ria_REG 1
1424461 | Nivell -01 PS1_PK | 2.48672 | 4.65 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1424472 | Nivell -01 PS1_PK | 2.80825 | 4.6682 | 17_XRX_1ria_REG 1
1430448 | Nivell -01 PS1_PK | 15.3668 | 4.9682 | 17_XRX_1ria_REG 1
1434253 | Nivell -01 PS1_PK | 3.49952 | 6.3082 | 17_XRX_1ria_REG 3
1434427 | Nivell -01 PS1_PK | 0.698877 | 5.6682 | 17_XRX_1ria_REG 3
1514882 | Nivell -01 PS1_PK | 2.21247 | 4.9932 | 17_XRX_1ria_REG 3
1517001 | Nivell -01 PS1_PK | 1.34223 | 5.4882 | 17_XRX_1ria_REG 3
1517036 | Nivell -01 PS1_PK | 1.53168 | 5.47 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1517044 | Nivell -01 PS1_PK | 1.72318 | 5.4564 | 03_FN_AFS 4
1517120 | Nivell -01 PS1_PK | 0.390225 | 5.08239 | 17_XRX_1ria_REG 3
1517155 | Nivell -01 PS1_PK | 0.359125 | 5.09294 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1517190 | Nivell -01 PS1_PK | 0.334625 | 5.10144 | 03_FN_AFS 4
1518570 | Nivell -01 PS1_PK | 7.72112 | 5.4564 | 03_FN_AFS 4
1518601 | Nivell -01 PS1_PK | 7.54662 | 5.47 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1518624 | Nivell -01 PS1_PK | 7.37827 | 5.4882 | 17_XRX_1ria_REG 3
1521364 | Nivell -01 PS1_PK | 0.275225 | 5.57739 | 17_XRX_1ria_REG 3
1521397 | Nivell -01 PS1_PK | 0.254125 | 5.57794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521428 | Nivell -01 PS1_PK | 0.237125 | 5.57894 | 03_FN_AFS 4
1521803 | Nivell -01 PS1_PK | 0.217775 | 5.60794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521806 | Nivell -01 PS1_PK | 5.85278 | 5.85 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521845 | Nivell -01 PS1_PK | 0.200775 | 5.60894 | 03_FN_AFS 4
1521848 | Nivell -01 PS1_PK | 1.36247 | 5.8364 | 03_FN_AFS 4
1523391 | Nivell -01 PS1_PK | 0.334125 | 5.95794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1523402 | Nivell -01 PS1_PK | 0.332125 | 5.95894 | 03_FN_AFS 4
1523413 | Nivell -01 PS1_PK | 0.335225 | 5.95739 | 17_XRX_1ria_REG 3
1554571 | Nivell -01 PS1_PK | 15.7752 | 3.8682 | 17_XRX_1ria_REG 1
1554573 | Nivell -01 PS1_PK | 15.7541 | 3.63 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1561543 | Nivell -01 PS1_PK | 0.0429548 | 4.09672 | 17_XRX_1ria_REG 3
1561572 | Nivell -01 PS1_PK | 15.338 | 4.07937 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1561583 | Nivell -01 PS1_PK | 0.221759 | 4.07653 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1561612 | Nivell -01 PS1_PK | 15.721 | 4.06569 | 03_FN_AFS 4
1561623 | Nivell -01 PS1_PK | 0.404683 | 4.06093 | 03_FN_AFS 4
1561819 | Nivell -01 PS1_PK | 0.345225 | 4.60739 | 17_XRX_1ria_REG 1
1561828 | Nivell -01 PS1_PK | 0.324125 | 4.60794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1561841 | Nivell -01 PS1_PK | 0.107125 | 4.60894 | 03_FN_AFS 4
1561854 | Nivell -01 PS1_PK | 0.345225 | 4.60739 | 03_FN_AFS 1
1563065 | Nivell -01 PS1_PK | 0.441042 | 4.4864 | 03_FN_AFS 4
1563077 | Nivell -01 PS1_PK | 2.59966 | 4.4864 | 03_FN_AFS 4
1563670 | Nivell -01 PS1_PK | 0.602668 | 4.805 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1563789 | Nivell -01 PS1_PK | 2.36583 | 4.5 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1563837 | Nivell -01 PS1_PK | 0.179125 | 4.60794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1563939 | Nivell -01 PS1_PK | 0.334836 | 4.7989 | 03_FN_AFS 4
1564007 | Nivell -01 PS1_PK | 0.169625 | 4.60894 | 03_FN_AFS 4
1564111 | Nivell -01 PS1_PK | 0.163275 | 4.61529 | 03_FN_AFS 4
1564114 | Nivell -01 PS1_PK | 2.13195 | 4.4864 | 03_FN_AFS 4
1567188 | Nivell -01 PS1_PK | 9.10653 | 4.9932 | 17_XRX_1ria_REG 3
1567206 | Nivell -01 PS1_PK | 11.2154 | 4.985 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567237 | Nivell -01 PS1_PK | 10.992 | 4.9789 | 03_FN_AFS 4
1567319 | Nivell -01 PS1_PK | 14.9591 | 4.09768 | 17_XRX_1ria_REG 3
1567329 | Nivell -01 PS1_PK | 0.035225 | 4.0982 | 17_XRX_1ria_REG 3
1567388 | Nivell -01 PS1_PK | 0.214117 | 4.08 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567436 | Nivell -01 PS1_PK | 0.397119 | 4.0664 | 03_FN_AFS 4
1567474 | Nivell -01 PS1_PK | 0.790225 | 4.18739 | 17_XRX_1ria_REG 3
1567520 | Nivell -01 PS1_PK | 0.779127 | 4.18794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567567 | Nivell -01 PS1_PK | 0.763275 | 4.18894 | 03_FN_AFS 4
1568185 | Nivell -01 PS1_PK | 12.7284 | 4.75 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1568506 | Nivell -01 PS1_PK | 2.93706 | 4.3 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1568508 | Nivell -01 PS1_PK | 3.14761 | 4.3182 | 17_XRX_1ria_REG 3
1568517 | Nivell -01 PS1_PK | 0.324125 | 4.40794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1568528 | Nivell -01 PS1_PK | 0.345225 | 4.40739 | 17_XRX_1ria_REG 3
1569198 | Nivell -01 PS1_PK | 0.995225 | 3.95739 | 17_XRX_1ria_REG 1
1569207 | Nivell -01 PS1_PK | 1.19413 | 3.73794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1569284 | Nivell -01 PS1_PK | 3.48373 | 4.7682 | 17_XRX_1ria_REG 3
1569294 | Nivell -01 PS1_PK | 9.39828 | 4.7682 | 17_XRX_1ria_REG 3
1571491 | Nivell -01 PS1_PK | 0.488563 | 4.9789 | 03_FN_AFS 4
1571499 | Nivell -01 PS1_PK | 1.91792 | 4.9789 | 03_FN_AFS 4
1572341 | Nivell -01 PS1_PK | 0.313443 | 3.8682 | 17_XRX_1ria_REG 1
1572352 | Nivell -01 PS1_PK | 1.05773 | 3.95739 | 17_XRX_1ria_REG 1
1572355 | Nivell -01 PS1_PK | 0.495225 | 5.0307 | 17_XRX_1ria_REG 1
1572388 | Nivell -01 PS1_PK | 0.302893 | 3.63 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572397 | Nivell -01 PS1_PK | 1.25663 | 3.73794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572400 | Nivell -01 PS1_PK | 0.663575 | 5.0125 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572665 | Nivell -01 PS1_PK | 9.87017 | 5.01322 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1575371 | Nivell -01 PS1_PK | 1.39528 | 5.0307 | 17_XRX_1ria_REG 1
1575388 | Nivell -01 PS1_PK | 1.66323 | 5.0125 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1575416 | Nivell -01 PS1_PK | 7.65159 | 4.95952 | 03_FN_AFS 4
1575523 | Nivell -01 PS1_PK | 0.734403 | 5.0307 | 17_XRX_1ria_REG 1
1575535 | Nivell -01 PS1_PK | 9.97843 | 5.0307 | 17_XRX_1ria_REG 1
1575573 | Nivell -01 PS1_PK | 0.725661 | 5.0225 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1575578 | Nivell -01 PS1_PK | 0.718723 | 4.9789 | 03_FN_AFS 4
1576412 | Nivell -01 PS1_PK | 1.30194 | 4.6364 | 03_FN_AFS 4
1576414 | Nivell -01 PS1_PK | 1.57237 | 4.65 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576416 | Nivell -01 PS1_PK | 1.84486 | 4.6682 | 17_XRX_1ria_REG 1
1576487 | Nivell -01 PS1_PK | 0.180241 | 4.75894 | 03_FN_AFS 4
1576543 | Nivell -01 PS1_PK | 0.237342 | 4.75794 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576595 | Nivell -01 PS1_PK | 0.257725 | 4.75739 | 17_XRX_1ria_REG 1
1577488 | Nivell -01 PS1_PK | 1.99181 | 4.97491 | 03_FN_AFS 4

# IfcFlowSegment: Pipe Types:PVC_Baixant (578)
Classification: 50.20.20.20 Canalitzacions d'aigües residuals (Uniformat)
Pset_DistributionFlowElementCommon - Reference: PVC_Baixant; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:PVC_Baixant:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1338640 | Nivell 08 P08_PC | 0.68473 | 37.4407 | 04_SN_APLU 1
1339197 | Nivell 08 P08_PC | 0.76819 | 37.3484 | 04_SN_APLU 2
1339220 | Nivell 08 P08_PC | 0.64473 | 37.4807 | 04_SN_APLU 2
1339227 | Nivell 08 P08_PC | 2.7961 | 37.3199 | 04_SN_APLU 2
1339250 | Nivell 08 P08_PC | 3.94648 | 33.3551 | 04_SN_APLU 2
1339260 | Nivell 08 P08_PC | 0.778202 | 37.5281 | 04_SN_APLU 3
1339272 | Nivell 08 P08_PC | 0.464759 | 37.6607 | 04_SN_APLU 3
1339284 | Nivell 08 P08_PC | 2.36125 | 37.5031 | 04_SN_APLU 3
1339421 | Nivell 07 P07_PP | 3.44905 | 33.8408 | 04_SN_APLU 1
1346738 | Nivell 07 P07_PP | 0.433675 | 33.7318 | 04_SN_APLU 11
1346750 | Nivell 07 P07_PP | 0.0647296 | 33.8607 | 04_SN_APLU 11
1346756 | Nivell 07 P07_PP | 3.46215 | 33.6965 | 04_SN_APLU 11
1347191 | Nivell 06 P06_PP | 21.7585 | 11.9198 | 04_SN_APLU 11
1347430 | Nivell 07 P07_PP | 3.64379 | 33.841 | 04_SN_APLU 3
1347435 | Nivell 08 P08_PC | 0.837706 | 37.4397 | 04_SN_APLU 3
1347439 | Nivell 07 P07_PP | 0.208278 | 37.313 | 04_SN_APLU 3
1347443 | Nivell 07 P07_PP | 3.23765 | 37.2791 | 04_SN_APLU 3
1347448 | Nivell 08 P08_PC | 0.802709 | 37.4747 | 04_SN_APLU 3
1347452 | Nivell 07 P07_PP | 0.214635 | 37.348 | 04_SN_APLU 3
1347461 | Nivell 07 P07_PP | 0.432677 | 33.7318 | 04_SN_APLU 8
1347463 | Nivell 07 P07_PP | 0.0647407 | 33.8607 | 04_SN_APLU 8
1347467 | Nivell 07 P07_PP | 3.57589 | 33.6954 | 04_SN_APLU 8
1347473 | Nivell 06 P06_PP | 0.951607 | 33.7069 | 04_SN_APLU 3
1347477 | Nivell 06 P06_PP | 28.8389 | 4.83826 | 04_SN_APLU 8
1347506 | Nivell 07 P07_PP | 0.463488 | 33.462 | 04_SN_APLU 3
1347629 | Nivell 07 P07_PP | 9.96741 | 33.1164 | 04_SN_APLU 2
1347641 | Nivell 07 P07_PP | 0.577666 | 33.3478 | 04_SN_APLU 2
1347647 | Nivell 07 P07_PP | 0.282399 | 32.9427 | 04_SN_APLU 10
1347661 | Nivell 07 P07_PP | 0.113126 | 32.9378 | 04_SN_APLU 17
1347683 | Nivell 07 P07_PP | 26.5379 | 6.33 | 04_SN_APLU 17
1348316 | Nivell 07 P07_PP | 3.97567 | 32.9461 | 04_SN_APLU 10
1348678 | Nivell 06 P06_PP | 0.651199 | 33.2176 | 04_SN_APLU 2
1348688 | Nivell 06 P06_PP | 0.377858 | 33.2247 | 04_SN_APLU 2
1348698 | Nivell 06 P06_PP | 0.146143 | 33.2291 | 04_SN_APLU 2
1348815 | Nivell 07 P07_PP | 0.0676144 | 33.0224 | 04_SN_APLU 10
1349028 | Nivell 07 P07_PP | 0.0553368 | 33.0692 | 04_SN_APLU 2
1349257 | Nivell 07 P07_PP | 0.155427 | 32.9408 | 04_SN_APLU 10
1349328 | Nivell 06 P06_PP | 0.228668 | 33.46 | 04_SN_APLU 3
1350063 | Nivell 06 P06_PP | 5.57886 | 32.9076 | 04_SN_APLU 3
1350292 | Nivell 05 P05_PP | 0.784318 | 25.8991 | 04_SN_APLU 5
1350304 | Nivell 05 P05_PP | 0.843906 | 26.0315 | 04_SN_APLU 5
1350310 | Nivell 05 P05_PP | 0.832196 | 25.8902 | 04_SN_APLU 5
1350327 | Nivell 05 P05_PP | 0.767404 | 25.8819 | 04_SN_APLU 5
1350534 | Nivell 05 P05_PP | 1.31227 | 25.873 | 04_SN_APLU 12
1350536 | Nivell 05 P05_PP | 0.86473 | 26.0107 | 04_SN_APLU 12
1350577 | Nivell 06 P06_PP | 0.931935 | 33.7069 | 04_SN_APLU 1
1350581 | Nivell 06 P06_PP | 0.228663 | 33.46 | 04_SN_APLU 1
1350597 | Nivell 06 P06_PP | 5.62688 | 32.9039 | 04_SN_APLU 1
1350599 | Nivell 06 P06_PP | 0.501494 | 32.9608 | 04_SN_APLU 1
1350708 | Nivell 07 P07_PP | 0.463488 | 33.462 | 04_SN_APLU 1
1351334 | Nivell 07 P07_PP | 3.35096 | 37.313 | 04_SN_APLU 3
1352324 | Nivell 08 P08_PC | 0.837706 | 37.4397 | 04_SN_APLU 4
1352328 | Nivell 07 P07_PP | 0.208278 | 37.313 | 04_SN_APLU 4
1352332 | Nivell 07 P07_PP | 3.23765 | 37.2791 | 04_SN_APLU 4
1352335 | Nivell 08 P08_PC | 0.802709 | 37.4747 | 04_SN_APLU 4
1352339 | Nivell 07 P07_PP | 0.214635 | 37.348 | 04_SN_APLU 4
1352345 | Nivell 07 P07_PP | 3.35096 | 37.313 | 04_SN_APLU 4
1352363 | Nivell 08 P08_PC | 0.798547 | 37.3081 | 04_SN_APLU 1
1352550 | Nivell 04 P04_PP | 1.64758 | 21.3946 | 04_SN_APLU 6
1352570 | Nivell 04 P04_PP | 0.839725 | 21.5357 | 04_SN_APLU 6
1352577 | Nivell 04 P04_PP | 0.351961 | 21.3895 | 04_SN_APLU 6
1352693 | Nivell 03 P03_PP | 1.10296 | 17.6991 | 04_SN_APLU 7
1352703 | Nivell 03 P03_PP | 0.79073 | 17.8347 | 04_SN_APLU 7
1352709 | Nivell 03 P03_PP | 0.144581 | 17.6962 | 04_SN_APLU 7
1352884 | Nivell 04 P04_PP | 1.65393 | 21.4396 | 04_SN_APLU 6
1352886 | Nivell 04 P04_PP | 0.79473 | 21.5807 | 04_SN_APLU 6
1352890 | Nivell 04 P04_PP | 4.35056 | 21.3946 | 04_SN_APLU 6
1353091 | Nivell 04 P04_PP | 1.64758 | 21.3946 | 04_SN_APLU 13
1353093 | Nivell 04 P04_PP | 0.839725 | 21.5357 | 04_SN_APLU 13
1353097 | Nivell 04 P04_PP | 0.351961 | 21.3895 | 04_SN_APLU 13
1353099 | Nivell 04 P04_PP | 7.04746 | 14.3239 | 04_SN_APLU 13
1353104 | Nivell 03 P03_PP | 1.10296 | 17.6991 | 04_SN_APLU 15
1353106 | Nivell 03 P03_PP | 0.79073 | 17.8347 | 04_SN_APLU 15
1353110 | Nivell 03 P03_PP | 0.144581 | 17.6962 | 04_SN_APLU 15
1353119 | Nivell 04 P04_PP | 1.65393 | 21.4396 | 04_SN_APLU 13
1353121 | Nivell 04 P04_PP | 0.79473 | 21.5807 | 04_SN_APLU 13
1353125 | Nivell 04 P04_PP | 4.35056 | 21.3946 | 04_SN_APLU 13
1362895 | Nivell -01 PS1_PK | 6.93781 | 5.30586 | 04_SN_APLU 14
1363806 | Nivell 07 P07_PP | 0.574936 | 33.8223 | 04_SN_AFEC 25
1363848 | Nivell 06 P06_PP | 3.76067 | 32.9544 | 04_SN_AFEC 25
1363858 | Nivell 06 P06_PP | 0.250721 | 32.9514 | 04_SN_AFEC 25
1363871 | Nivell 06 P06_PP | 0.180658 | 32.949 | 04_SN_AFEC 25
1363881 | Nivell 06 P06_PP | 0.156477 | 32.7148 | 04_SN_AFEC 25
1363984 | Nivell 06 P06_PP | 0.1068 | 32.8261 | 04_SN_AFEC 25
1364005 | Nivell 06 P06_PP | 22.5552 | 10.1086 | 04_SN_AFEC 1
1364289 | Nivell 06 P06_PP | 0.307286 | 33.2125 | 04_SN_AFEC 25
1364311 | Nivell 06 P06_PP | 0.349653 | 33.2159 | 04_SN_AFEC 25
1366605 | Nivell 06 P06_PP | 2.97069 | 33.6829 | 04_SN_AFEC 25
1366671 | Nivell 06 P06_PP | 0.337623 | 33.3291 | 04_SN_AFEC 25
1367745 | Nivell 06 P06_PP | 1.48994 | 29.1977 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 2
1367756 | Nivell 06 P06_PP | 3.05233 | 29.1666 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 2
1367791 | Nivell 05 P05_PP | 0.837689 | 29.3223 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 2
1368424 | Nivell 06 P06_PP | 1.71164 | 29.0632 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 1
1368426 | Nivell 05 P05_PP | 0.989013 | 29.171 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 1
1368508 | Nivell 05 P05_PP | 2.89527 | 29.0338 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 1
1368688 | Nivell 06 P06_PP | 1.48994 | 29.1977 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 3
1368690 | Nivell 06 P06_PP | 3.05233 | 29.1666 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 3
1368694 | Nivell 05 P05_PP | 0.837689 | 29.3223 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 3
1368698 | Nivell 06 P06_PP | 1.68974 | 29.0766 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368700 | Nivell 05 P05_PP | 0.975843 | 29.1842 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368745 | Nivell 06 P06_PP | 3.1468 | 29.2939 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368747 | Nivell 05 P05_PP | 0.743932 | 29.4161 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368796 | Nivell 05 P05_PP | 0.218699 | 29.2913 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368938 | Nivell 05 P05_PP | 0.437689 | 29.7223 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369135 | Nivell 05 P05_PP | 3.4141 | 29.5784 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369144 | Nivell 05 P05_PP | 0.844595 | 29.5695 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369154 | Nivell 05 P05_PP | 18.5301 | 29.0295 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369164 | Nivell 05 P05_PP | 0.863185 | 29.0204 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369207 | Nivell 05 P05_PP | 0.179436 | 29.5672 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369304 | Nivell 05 P05_PP | 0.22646 | 29.3246 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369414 | Nivell 05 P05_PP | 0.361791 | 29.0162 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369541 | Nivell 05 P05_PP | 0.437689 | 29.7223 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369545 | Nivell 05 P05_PP | 3.4141 | 29.5784 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369547 | Nivell 05 P05_PP | 0.844595 | 29.5695 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369551 | Nivell 05 P05_PP | 18.5301 | 29.0295 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369553 | Nivell 05 P05_PP | 0.863185 | 29.0204 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369557 | Nivell 05 P05_PP | 0.179436 | 29.5672 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369559 | Nivell 05 P05_PP | 0.22646 | 29.3246 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369567 | Nivell 05 P05_PP | 0.361791 | 29.0162 | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369582 | Nivell 06 P06_PP | 22.4963 | 10.1674 | 04_SN_AFEC 6
1369584 | Nivell 07 P07_PP | 22.0008 | 10.8779 | 04_SN_AGRIS 5
1369697 | Nivell 07 P07_PP | 22.2 | 10.6787 | 04_SN_APLU 22
1370428 | Nivell 02 P02_PP | 1.48994 | 14.1977 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 15
1370430 | Nivell 02 P02_PP | 4.95223 | 14.1476 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 15
1370434 | Nivell 01 P01_PP | 0.837689 | 14.3223 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 15
1370438 | Nivell 02 P02_PP | 1.70401 | 14.0953 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 12
1370440 | Nivell 01 P01_PP | 0.957011 | 14.203 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 12
1370444 | Nivell 01 P01_PP | 4.85507 | 14.0463 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 12
1370464 | Nivell 02 P02_PP | 1.48994 | 14.1977 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 17
1370466 | Nivell 02 P02_PP | 4.95223 | 14.1476 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 17
1370470 | Nivell 01 P01_PP | 0.837689 | 14.3223 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 17
1370474 | Nivell 02 P02_PP | 1.7093 | 14.0679 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370476 | Nivell 01 P01_PP | 0.984326 | 14.1757 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370480 | Nivell 01 P01_PP | 4.44314 | 14.023 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370500 | Nivell 02 P02_PP | 3.14681 | 14.2929 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370502 | Nivell 01 P01_PP | 0.744932 | 14.4151 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370504 | Nivell 01 P01_PP | 0.218578 | 14.2903 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370522 | Nivell 01 P01_PP | 0.437689 | 14.7223 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370530 | Nivell 01 P01_PP | 3.4141 | 14.5784 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370532 | Nivell 01 P01_PP | 0.844595 | 14.5695 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370536 | Nivell 01 P01_PP | 21.7301 | 13.9975 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370538 | Nivell 01 P01_PP | 0.863262 | 13.9884 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370542 | Nivell 01 P01_PP | 0.179436 | 14.5672 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370544 | Nivell 01 P01_PP | 0.22646 | 14.3246 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370552 | Nivell 01 P01_PP | 0.361417 | 13.9842 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370556 | Nivell 01 P01_PP | 0.437689 | 14.7223 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370560 | Nivell 01 P01_PP | 3.4141 | 14.5784 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370562 | Nivell 01 P01_PP | 0.844595 | 14.5695 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370566 | Nivell 01 P01_PP | 21.7301 | 13.9975 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370568 | Nivell 01 P01_PP | 0.863262 | 13.9884 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370572 | Nivell 01 P01_PP | 0.179436 | 14.5672 | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
