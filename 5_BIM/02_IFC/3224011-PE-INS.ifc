Properties of the parts of a building model (IFC2X3), part 7 of 11

# IfcFlowFitting: M_Codo - Genérico:Estándar (873)
Name (M_Codo - Genérico:Estándar:...) | In | Group
1390664 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1391950 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1391962 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1392454 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1392456 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1392479 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1392481 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1399439 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1399443 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1399576 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1399594 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1402585 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1402587 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1402596 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1405558 | Nivell 06 P06_PP | 04_SN_AFEC 25
1405670 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_BIE 6
1405722 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1405732 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1405744 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1406532 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 13
1406546 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1406550 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1406568 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_BIE 17
1406582 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1406586 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1406604 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_BIE 21
1406614 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1406618 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1406622 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1407273 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 9
1407287 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1407291 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1407462 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1407466 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1407490 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1407494 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1407607 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1407617 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1407777 | Nivell 00 P00_PB | 11_CI_BIE 1
1407839 | Nivell 00 P00_PB | 11_CI_BIE 1
1408346 | Nivell -01 PS1_PK | 11_CI_BIE 1
1408369 | Nivell -01 PS1_PK | 11_CI_BIE 1
1408528 | Nivell -01 PS1_PK | 11_CI_BIE 1
1408651 | Nivell -01 PS1_PK | 11_CI_BIE 1
1409015 | Nivell -01 PS1_PK | 11_CI_BIE 1
1409017 | Nivell -01 PS1_PK | 11_CI_BIE 1
1411069 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1411632 | Nivell 00 P00_PB | 11_CI_RUIX 5
1411644 | Nivell 00 P00_PB | 11_CI_RUIX 5
1413332 | Nivell -01 PS1_PK | 03_FN_AFS 4
1413334 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1413614 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1414986 | Nivell -01 PS1_PK | 03_FN_AFS 1
1421102 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 5
1421104 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 5
1421106 | Nivell 00 P00_PB | 03_FN_AFS 6
1421108 | Nivell 00 P00_PB | 03_FN_AFS 6
1421530 | Nivell 00 P00_PB | 11_CI_BIE 1
1421543 | Nivell 00 P00_PB | 11_CI_BIE 1
1421547 | Nivell 00 P00_PB | 11_CI_BIE 1
1421606 | Nivell 00 P00_PB | 11_CI_BIE 1
1421610 | Nivell 00 P00_PB | 11_CI_BIE 1
1422083 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1422085 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1422231 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1422233 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1422399 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1422401 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1422589 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1422591 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1422675 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1422677 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1432156 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432157 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1432158 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432164 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432176 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432178 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432180 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1432188 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432194 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432200 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432206 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432208 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432210 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1432214 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1434350 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1434522 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1435216 | Nivell -01 PS1_PK | 04_SN_AFEC 13
1435926 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1435966 | Nivell -01 PS1_PK | 04_SN_AFEC 24
1436050 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1437225 | Nivell 05 P05_PP | 04_SN_APLU 12
1441524 | Nivell 06 P06_PP | 04_SN_APLU 3
1442028 | Nivell 06 P06_PP | 04_SN_APLU 3
1442516 | Nivell 07 P07_PP | 04_SN_APLU 3
1442538 | Nivell 06 P06_PP | 04_SN_APLU 3
1442854 | Nivell 06 P06_PP | 04_SN_APLU 3
1442900 | Nivell 06 P06_PP | 04_SN_APLU 1
1442904 | Nivell 06 P06_PP | 04_SN_APLU 1
1442910 | Nivell 06 P06_PP | 04_SN_APLU 1
1443098 | Nivell 06 P06_PP | 04_SN_APLU 1
1443614 | Nivell 06 P06_PP | 04_SN_APLU 1
1443643 | Nivell 06 P06_PP | 04_SN_APLU 1
1443647 | Nivell 06 P06_PP | 04_SN_APLU 1
1444058 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1444062 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1444193 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1444195 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1455669 | Nivell 06 P06_PP | 04_SN_AFEC 25
1455671 | Nivell 06 P06_PP | 04_SN_AFEC 25
1460464 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 19
1462585 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1462970 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1462994 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464027 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464154 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464391 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464594 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464596 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464604 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464613 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464615 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464623 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464740 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464742 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464755 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464957 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1464959 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1464963 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1465177 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1465292 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1466575 | Nivell 00 P00_PB | 11_CI_BIE 32
1466677 | Nivell 00 P00_PB | 11_CI_BIE 32
1466679 | Nivell 00 P00_PB | 11_CI_BIE 32
1466683 | Nivell 00 P00_PB | 11_CI_BIE 32
1467525 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1467535 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1467545 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1467555 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1469326 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1469328 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1469335 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1469337 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1469346 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1469348 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1469355 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1469357 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1473144 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1473159 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1473176 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1473178 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1473182 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1473188 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1473190 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1477098 | Nivell -01 PS1_PK | 04_SN_AFEC 10
1478792 | Nivell -01 PS1_PK | 04_SN_AFEC 10
1481511 | Nivell 00 P00_PB | 04_SN_AGRIS 18
1481543 | Nivell 00 P00_PB | 04_SN_AGRIS 18
1482784 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1483154 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1483542 | Nivell 00 P00_PB | 04_SN_AFEC 10
1484061 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1484065 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1484313 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1484572 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1484584 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1484615 | Nivell -03 PS2_PK | 04_SN_AGRIS 7
1484665 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1485799 | Nivell 00 P00_PB | 11_CI_BIE 1
1485817 | Nivell 00 P00_PB | 11_CI_RUIX 5
1485821 | Nivell 00 P00_PB | 11_CI_RUIX 5
1486674 | Nivell 00 P00_PB | 11_CI_BIE 1
1486676 | Nivell 00 P00_PB | 11_CI_BIE 1
1487219 | Nivell 00 P00_PB | 11_CI_BIE 1
1487229 | Nivell 00 P00_PB | 11_CI_BIE 1
1487252 | Nivell 00 P00_PB | 11_CI_RUIX 5
1487260 | Nivell 00 P00_PB | 11_CI_RUIX 5
1487264 | Nivell 00 P00_PB | 11_CI_RUIX 5
1487456 | Nivell 00 P00_PB | 11_CI_BIE 1
1487469 | Nivell 00 P00_PB | 11_CI_BIE 1
1487471 | Nivell 00 P00_PB | 11_CI_BIE 1
1488826 | Nivell 00 P00_PB | 03_FN_AFS 7
1488908 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489195 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1489199 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1489207 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1489209 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1489213 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1489874 | Nivell 00 P00_PB | 03_FN_AFS 7
1489876 | Nivell 00 P00_PB | 03_FN_AFS 7
1489880 | Nivell 00 P00_PB | 03_FN_AFS 7
1489885 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489887 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489894 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489905 | Nivell 00 P00_PB | 03_FN_AFS 7
1491563 | Nivell 00 P00_PB | 03_FN_AFS 7
1491571 | Nivell 00 P00_PB | 03_FN_AFS 7
1491575 | Nivell 00 P00_PB | 03_FN_AFS 7
1491599 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1491607 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1491611 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1492643 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1492645 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1492657 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1492672 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1492674 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1492686 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1493138 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1493141 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1493146 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1493149 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1493159 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1493162 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1493169 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1493172 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494256 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494307 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494361 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494416 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494702 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494704 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494711 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494713 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494720 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494722 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494729 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1494731 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1495909 | Nivell 00 P00_PB | 03_FN_AFS 7
1495991 | Nivell 00 P00_PB | 03_FN_AFS 7
1495993 | Nivell 00 P00_PB | 03_FN_AFS 7
1496005 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1496008 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1496010 | Nivell 00 P00_PB | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1497506 | Nivell 00 P00_PB | 11_CI_BIE 1
1497510 | Nivell 00 P00_PB | 11_CI_BIE 1
1497518 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1497522 | Nivell 00 P00_PB | 11_CI_RUIX 5
1498996 | Nivell 00 P00_PB | 11_CI_BIE 1
1499000 | Nivell -01 PS1_PK | 11_CI_BIE 1
1499036 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1499040 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1500576 | Nivell -01 PS1_PK | 04_SN_AGRIS 23
1500580 | Nivell 00 P00_PB | 04_SN_AGRIS 23
1501075 | Nivell 04 P04_PP | 04_SN_APLU 13
1501760 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 19
1503366 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1503370 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1503378 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1503784 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1504144 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1504221 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1504336 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1505104 | Nivell 00 P00_PB | 04_SN_AGRIS 6
1505174 | Nivell 00 P00_PB | 04_SN_AGRIS 6
1505325 | Nivell 00 P00_PB | 04_SN_AGRIS 6
1506025 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1506051 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1506061 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1506174 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1506726 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1506793 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1507690 | Nivell -01 PS1_PK | 04_SN_AFEC 24
1507694 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1507735 | Nivell -01 PS1_PK | 04_SN_AGRIS 4
1508309 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1508311 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1508377 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1508519 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1509523 | Nivell -01 PS1_PK | 04_SN_APLU 25
1514877 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1515956 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1516041 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1516053 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1517122 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1517130 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1517132 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1517157 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1517167 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1517192 | Nivell -01 PS1_PK | 03_FN_AFS 4
1517202 | Nivell -01 PS1_PK | 03_FN_AFS 4
1520630 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1520677 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1521082 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1521092 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521102 | Nivell -01 PS1_PK | 03_FN_AFS 4
1521282 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1521294 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1521319 | Nivell -01 PS1_PK | 11_CI_BIE 1
1521366 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1521399 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521430 | Nivell -01 PS1_PK | 03_FN_AFS 4
1521539 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1521541 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1521569 | Nivell -01 PS1_PK | 11_CI_BIE 1
1521573 | Nivell -01 PS1_PK | 11_CI_BIE 1
1521596 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1521629 | Nivell -01 PS1_PK | 11_CI_BIE 1
1521639 | Nivell -01 PS1_PK | 11_CI_BIE 1
1521813 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521815 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521857 | Nivell -01 PS1_PK | 03_FN_AFS 4
1521894 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521930 | Nivell -01 PS1_PK | 03_FN_AFS 4
1523393 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1523395 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1523399 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1523404 | Nivell -01 PS1_PK | 03_FN_AFS 4
1523406 | Nivell -01 PS1_PK | 03_FN_AFS 4
1523410 | Nivell -01 PS1_PK | 03_FN_AFS 4
1523415 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1523417 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1523421 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1528739 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1528741 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1528745 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1528747 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1528757 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1532782 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533025 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533153 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533195 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533199 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533280 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1533284 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1534667 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1535405 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 26
1535428 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535434 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535600 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535610 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1535614 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 14
1536096 | Nivell 00 P00_PB | 11_CI_BIE 1
1536098 | Nivell 00 P00_PB | 11_CI_BIE 1
1536488 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1536680 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1536855 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1536859 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1537287 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1537360 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537421 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537425 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537435 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537451 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1537461 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1538067 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1538220 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1538519 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538529 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538864 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1538868 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1539601 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540019 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540298 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540541 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540557 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1541014 | Nivell 00 P00_PB | 04_SN_AFEC 16
1541018 | Nivell 00 P00_PB | 04_SN_AFEC 16
1541022 | Nivell 00 P00_PB | 04_SN_AFEC 16
1541203 | Nivell 00 P00_PB | 04_SN_AFEC 16
1541207 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1541602 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1542258 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1543686 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1543690 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1544632 | Nivell 01 P01_PP | 04_SN_APLU 21
1544642 | Nivell 01 P01_PP | 04_SN_APLU 21
1546052 | Nivell 01 P01_PP | 04_SN_APLU 21
1546064 | Nivell 01 P01_PP | 04_SN_APLU 21
1546188 | Nivell 01 P01_PP | 04_SN_APLU 21
1546252 | Nivell 01 P01_PP | 04_SN_APLU 16
1546256 | Nivell 01 P01_PP | 04_SN_APLU 16
1546260 | Nivell 01 P01_PP | 04_SN_APLU 16
1546262 | Nivell 01 P01_PP | 04_SN_APLU 16
1546268 | Nivell 01 P01_PP | 04_SN_APLU 16
1546846 | Nivell -01 PS1_PK | 04_SN_APLU 9
1546918 | Nivell -01 PS1_PK | 04_SN_APLU 9
1546934 | Nivell 00 P00_PB | 04_SN_APLU 9
1547098 | Nivell 00 P00_PB | 04_SN_APLU 9
1547453 | Nivell -03 PS2_PK | 04_SN_APLU 24
1547484 | Nivell 00 P00_PB | 04_SN_APLU 9
1547488 | Nivell -01 PS1_PK | 04_SN_APLU 9
1548049 | Nivell -01 PS1_PK | 04_SN_APLU 9
1548541 | Nivell -01 PS1_PK | 04_SN_APLU 9
1548551 | Nivell -01 PS1_PK | 04_SN_APLU 9
1548816 | Nivell -01 PS1_PK | 04_SN_APLU 9
1549269 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1549406 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1549442 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1550918 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1550922 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1551022 | Nivell 00 P00_PB | 04_SN_AFEC 7
1551110 | Nivell -01 PS1_PK | 11_CI_BIE 1
1551221 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 1
1551231 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 1
1551288 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 11
1551294 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1551296 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1551308 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1551310 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1551314 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1551315 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1552608 | Nivell -01 PS1_PK | 04_SN_APLU 9
1552613 | Nivell -01 PS1_PK | 04_SN_APLU 9
1554223 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1554225 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1554233 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1554235 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1554243 | Nivell -01 PS1_PK | 03_FN_AFS 4
1554245 | Nivell -01 PS1_PK | 03_FN_AFS 4
1554396 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1554398 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1554405 | Nivell -01 PS1_PK | 11_CI_BIE 1
1554407 | Nivell -01 PS1_PK | 11_CI_BIE 1
1554428 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1554436 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1554440 | Nivell -01 PS1_PK | 11_CI_RUIX 5
1554463 | Nivell -01 PS1_PK | 11_CI_BIE 1
1554473 | Nivell -01 PS1_PK | 11_CI_BIE 1
1556992 | Nivell -01 PS1_PK | 04_SN_APLU 23
1556998 | Nivell -01 PS1_PK | 04_SN_APLU 23
1557000 | Nivell -01 PS1_PK | 04_SN_APLU 23
1557267 | Nivell -01 PS1_PK | 04_SN_APLU 23
1558046 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1558117 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1558121 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1558123 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1558129 | Nivell -01 PS1_PK | 04_SN_APLU 14
1558135 | Nivell -01 PS1_PK | 04_SN_APLU 14
1558137 | Nivell -01 PS1_PK | 04_SN_APLU 18
1558141 | Nivell -01 PS1_PK | 04_SN_AFEC 16
1558407 | Nivell -01 PS1_PK | 04_SN_APLU 14
1558540 | Nivell -01 PS1_PK | 04_SN_APLU 20
1558543 | Nivell -01 PS1_PK | 04_SN_APLU 20
1559340 | Nivell -01 PS1_PK | 04_SN_APLU 20
1560750 | Nivell -01 PS1_PK | 03_FN_AFS 1
1561087 | Nivell -01 PS1_PK | 11_CI_BIE 1
1561089 | Nivell -01 PS1_PK | 11_CI_BIE 1
1561358 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1561372 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1561376 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1561639 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1561644 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1561650 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1561655 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1561661 | Nivell -01 PS1_PK | 03_FN_AFS 4
1561666 | Nivell -01 PS1_PK | 03_FN_AFS 4
1561821 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1561823 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1561830 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1561832 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1561843 | Nivell -01 PS1_PK | 03_FN_AFS 4
1561845 | Nivell -01 PS1_PK | 03_FN_AFS 4
1561849 | Nivell -01 PS1_PK | 03_FN_AFS 4
1561856 | Nivell -01 PS1_PK | 03_FN_AFS 1
1561858 | Nivell -01 PS1_PK | 03_FN_AFS 1
1561862 | Nivell -01 PS1_PK | 03_FN_AFS 1
1563839 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1563847 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1563851 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1564017 | Nivell -01 PS1_PK | 03_FN_AFS 4
1564019 | Nivell -01 PS1_PK | 03_FN_AFS 4
1564121 | Nivell -01 PS1_PK | 03_FN_AFS 4
1564125 | Nivell -01 PS1_PK | 03_FN_AFS 4
1567335 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1567396 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567444 | Nivell -01 PS1_PK | 03_FN_AFS 4
1567476 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1567486 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1567522 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567533 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567535 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1567569 | Nivell -01 PS1_PK | 03_FN_AFS 4
1567578 | Nivell -01 PS1_PK | 03_FN_AFS 4
1568002 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1568008 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1568015 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1568021 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1568521 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1568530 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1568762 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1568766 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1568772 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1568776 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1569200 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1569202 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1569209 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1569211 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1569289 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1572358 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1572362 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1572403 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572407 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572941 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1572945 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1572947 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1575175 | Nivell -01 PS1_PK | 11_CI_BIE 1
1575589 | Nivell -01 PS1_PK | 03_FN_AFS 4
1575604 | Nivell -01 PS1_PK | 03_FN_AFS 4
1575623 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1575627 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576441 | Nivell -01 PS1_PK | 03_FN_AFS 4
1576443 | Nivell -01 PS1_PK | 03_FN_AFS 4
1576445 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576447 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576449 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1576451 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1576489 | Nivell -01 PS1_PK | 03_FN_AFS 4
1576503 | Nivell -01 PS1_PK | 03_FN_AFS 4
1576510 | Nivell -01 PS1_PK | 03_FN_AFS 4
1576545 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576560 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576564 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1576597 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1576605 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1576607 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1577046 | Nivell -01 PS1_PK | 11_CI_BIE 1
1577709 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1577748 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1577868 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1577879 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1578008 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1578011 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1578017 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1578020 | Nivell -01 PS1_PK | 05_CA_AC_RET 12
1580817 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1580859 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1580864 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 8
1580966 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1581238 | Nivell -01 PS1_PK | 04_SN_APLU 11
1581788 | Nivell -01 PS1_PK | 04_SN_AFEC 28
1581795 | Nivell 00 P00_PB | 04_SN_AFEC 28
1581909 | Nivell -01 PS1_PK | 04_SN_APLU 20
1581911 | Nivell -01 PS1_PK | 04_SN_APLU 20
1584660 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1585595 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1585599 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1585712 | Nivell -01 PS1_PK | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1585716 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586065 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586069 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586103 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586343 | Nivell -01 PS1_PK | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1586353 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1589230 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1589234 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1589239 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1589243 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1593765 | Nivell 07 P07_PP | 04_SN_APLU 17
1593947 | Nivell -01 PS1_PK | 04_SN_APLU 9
1593951 | Nivell -01 PS1_PK | 04_SN_APLU 9
1594665 | Nivell 06 P06_PP | 04_SN_APLU 11
1594948 | Nivell 06 P06_PP | 04_SN_APLU 11
1594950 | Nivell 06 P06_PP | 04_SN_APLU 11
1595057 | Nivell 06 P06_PP | 04_SN_APLU 11
1595839 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1595843 | Nivell -01 PS1_PK | 04_SN_ABOM 1

# IfcFlowFitting: M_Codo - Genérico:Estándar (9)
Type - Material: ARC_METALL_AN
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (M_Codo - Genérico:Estándar:...) | In | Group
1405710 | Nivell 06 P06_PP | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3
1406538 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1406574 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1406610 | Nivell 05 P05_PP | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8
1407279 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1551292 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1575533 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 1
1576993 | Nivell -01 PS1_PK | 11_CI_BIE 1
1577044 | Nivell -01 PS1_PK | 11_CI_BIE 1

# IfcFlowFitting: M_Codo horizontal de canal:EL (24)
Type - Material: <Unnamed>
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EL; sets with these values: 2
Name (M_Codo horizontal de canal:EL:...) | In | Group
1425129 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1425439 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427424 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427676 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427707 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427714 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427737 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427768 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427775 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427798 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427829 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427836 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427859 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427890 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427897 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427920 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1427951 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1427958 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1495511 | Nivell 00 P00_PB
1496082 | Nivell 00 P00_PB
1527860 | Nivell -01 PS1_PK
1528567 | Nivell -01 PS1_PK
1528568 | Nivell -01 PS1_PK
1528569 | Nivell -01 PS1_PK

# IfcFlowFitting: M_Codo horizontal de canal:Gasos (2)
In: Nivell 00 P00_PB
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Gasos; sets with these values: 2
Name (M_Codo horizontal de canal:Gasos:...)
1490506
1491846

# IfcFlowFitting: M_Codo horizontal de canal:SF (8)
Type - Material: <Unnamed>
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SF; sets with these values: 2
Name (M_Codo horizontal de canal:SF:...) | In | Group
1425088 | Nivell 07 P07_PP
1425091 | Nivell 07 P07_PP
1425349 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427704 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427765 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427826 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427887 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427948 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957

# IfcFlowFitting: M_Codo rectangular - Radio:APT_1 W (28)
Type - Material: <Unnamed>
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: APT_1 W; sets with these values: 2
Name (M_Codo rectangular - Radio:APT_1 W:...) | In | Group
1342244 | Nivell 00 P00_PB | VEN_APT 8
1343364 | Nivell 07 P07_PP | VEN_APT 4
1343442 | Nivell 07 P07_PP | VEN_APT 4
1343457 | Nivell 07 P07_PP | VEN_APT 1
1343859 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1344353 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344393 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344433 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344473 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344513 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1345635 | Nivell -01 PS1_PK | VEN_APT 6
1345637 | Nivell -01 PS1_PK | VEN_APT 6
1346012 | Nivell 00 P00_PB | VEN_APT 11
1346020 | Nivell 00 P00_PB | VEN_APT 11
1346021 | Nivell 00 P00_PB | VEN_APT 11
1468710 | Nivell 07 P07_PP | VEN_APT 2
1471530 | Nivell -01 PS1_PK | VEN_APT 6
1471809 | Nivell 00 P00_PB | VEN_APT 8
1471810 | Nivell -01 PS1_PK | VEN_APT 8
1499844 | Nivell -01 PS1_PK | VEN_APT 6
1518250 | Nivell -01 PS1_PK | VEN_APT 6
1518251 | Nivell -01 PS1_PK | VEN_APT 6
1518315 | Nivell -01 PS1_PK | VEN_APT 6
1518317 | Nivell -01 PS1_PK | VEN_APT 6
1523252 | Nivell -01 PS1_PK | VEN_APT 6
1523253 | Nivell -01 PS1_PK | VEN_APT 6
1523293 | Nivell -01 PS1_PK | VEN_APT 6
1523294 | Nivell -01 PS1_PK | VEN_APT 6

# IfcFlowFitting: M_Codo rectangular - Radio:EXT_1 W (54)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_1 W; sets with these values: 2
Name (M_Codo rectangular - Radio:EXT_1 W:...) | In | Group
1342517 | Nivell 00 P00_PB | VEN_EXT 8
1342564 | Nivell 00 P00_PB | VEN_EXT 8
1343368 | Nivell 08 P08_PC | VEN_APT 4
1343450 | Nivell 08 P08_PC | VEN_APT 1
1343485 | Nivell 08 P08_PC | VEN_APT 1
1343979 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1343986 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1343987 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 10
1344358 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344361 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344362 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 11
1344398 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344401 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344402 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 15
1344438 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344441 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344442 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 19
1344478 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344481 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344482 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 23
1344518 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1344521 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1344522 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 27
1345617 | Nivell -01 PS1_PK | VEN_EXT 7
1345619 | Nivell -01 PS1_PK | VEN_EXT 7
1345823 | Nivell 00 P00_PB | VEN_EXT 12
1345940 | Nivell 00 P00_PB | VEN_EXT 14
1388513 | Nivell 06 P06_PP | VEN_EXT 5
1440678 | Nivell 07 P07_PP | VEN_EXT 5
1440831 | Nivell 06 P06_PP | VEN_EXT 5
1440835 | Nivell 06 P06_PP | VEN_EXT 5
1445123 | Nivell 06 P06_PP | VEN_EXT 3
1445126 | Nivell 06 P06_PP | VEN_EXT 3
1445450 | Nivell 06 P06_PP | VEN_EXT 3
1445451 | Nivell 07 P07_PP | VEN_EXT 3
1453408 | Nivell 06 P06_PP | VEN_EXT 5
1468966 | Nivell 07 P07_PP | VEN_EXT 2
1469083 | Nivell 07 P07_PP | VEN_EXT 2
1471234 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1471533 | Nivell -01 PS1_PK | VEN_EXT 7
1471791 | Nivell -01 PS1_PK | VEN_EXT 8
1471793 | Nivell 00 P00_PB | VEN_EXT 8
1472519 | Nivell -01 PS1_PK | VEN_EXT 7
1474916 | Nivell 00 P00_PB | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_RET 4
1475898 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475924 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3
1499812 | Nivell -01 PS1_PK | VEN_EXT 7
1518230 | Nivell -01 PS1_PK | VEN_EXT 7
1518231 | Nivell -01 PS1_PK | VEN_EXT 7
1518324 | Nivell -01 PS1_PK | VEN_EXT 7
1518326 | Nivell -01 PS1_PK | VEN_EXT 7
1518895 | Nivell -01 PS1_PK | VEN_EXT 7
1592927 | Nivell 07 P07_PP | VEN_EXT 4
1592997 | Nivell 07 P07_PP | VEN_EXT 24

# IfcFlowFitting: M_Codo rectangular - Radio:IMP_1 W (11)
In: Nivell 00 P00_PB
Type - Material: <Unnamed>
Classification: 50.30.40.30 Impulsió de aire tractat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: IMP_1 W; sets with these values: 2
Name (M_Codo rectangular - Radio:IMP_1 W:...) | Group
1587321 | CLI_RET 7
1587324 | CLI_RET 7
1588227 | CLI_IMP 11
1588232 | CLI_IMP 11
1588233 | CLI_IMP 11
1588373 | CLI_RET 8
1588383 | CLI_RET 8
1588613 | CLI_IMP 7
1588615 | CLI_IMP 7
1588630 | CLI_RET 12
1588632 | CLI_RET 12

# IfcFlowFitting: M_Codo redondo:EXT_1 D (166)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_1 D; sets with these values: 2
Name (M_Codo redondo:EXT_1 D:...) | In | Group
1341839 | Nivell -01 PS1_PK | VEN_EXT 6
1342060 | Nivell -01 PS1_PK | VEN_EXT 6
1342064 | Nivell -01 PS1_PK | VEN_EXT 6
1344015 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344029 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344038 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344066 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_EXT 9
1344367 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344371 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344373 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344379 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_EXT 13
1344407 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344411 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344413 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344419 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_EXT 17
1344447 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344451 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344453 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344459 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_EXT 21
1344487 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344491 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344493 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344499 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_EXT 25
1344527 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344531 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344533 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1344539 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_EXT 29
1394430 | Nivell 00 P00_PB | VEN_EXT 16
1437624 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 40
1439005 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439212 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439226 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 40
1439349 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 41
1439360 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439370 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439374 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 41
1439669 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 44
1439680 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439690 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439694 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 44
1439707 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 45
1439718 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439728 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439732 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 45
1439902 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 46
1439913 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439923 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439927 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 46
1439940 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 48
1439951 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439961 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1439965 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 48
1446440 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446448 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446457 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1446477 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446485 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446494 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1446866 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446874 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446883 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1446898 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446906 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1446915 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1453534 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454143 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454147 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454251 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454253 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 31
1454351 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1454355 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1454363 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1454367 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1454896 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455446 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455448 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455452 | Nivell 00 P00_PB | Model Group:05_VEN_Extr banys PB:1454726; VEN_EXT 34
1455868 | Nivell -01 PS1_PK | VEN_EXT 16
1458465 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458480 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458489 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458866 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458872 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458876 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458884 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458890 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458894 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458902 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458908 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458912 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458920 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458926 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458930 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458938 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1458944 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1458948 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1459040 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459061 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459070 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459289 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459295 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459299 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459305 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459311 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459315 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459337 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1459343 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1459347 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1471951 | Nivell 00 P00_PB | VEN_EXT 16
1471953 | Nivell 06 P06_PP | VEN_EXT 16
1474560 | Nivell -01 PS1_PK | VEN_EXT 6
1474575 | Nivell -01 PS1_PK | VEN_EXT 6
1474588 | Nivell -01 PS1_PK | VEN_EXT 6
1474605 | Nivell -01 PS1_PK | VEN_EXT 6
1476636 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476642 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476644 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476653 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476654 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476657 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476659 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476661 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476663 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476799 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476805 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476807 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476816 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476817 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476820 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476822 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476824 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476826 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1485981 | Nivell 00 P00_PB | VEN_EXT 16
1487294 | Nivell 00 P00_PB | VEN_EXT 16
1487302 | Nivell 00 P00_PB | VEN_EXT 16
1487306 | Nivell 00 P00_PB | VEN_EXT 16
1498284 | Nivell -01 PS1_PK | VEN_EXT 16
1499493 | Nivell -01 PS1_PK | VEN_EXT 16
1499616 | Nivell -01 PS1_PK | VEN_EXT 16
1499620 | Nivell 00 P00_PB | VEN_EXT 16
1541371 | Nivell -01 PS1_PK | VEN_EXT 6
1541475 | Nivell -01 PS1_PK | VEN_EXT 6
1543333 | Nivell -01 PS1_PK | VEN_EXT 6
1551886 | Nivell -01 PS1_PK | VEN_EXT 6
1551896 | Nivell -01 PS1_PK | VEN_EXT 6
1551974 | Nivell -01 PS1_PK | VEN_EXT 6
1551976 | Nivell -01 PS1_PK | VEN_EXT 6
1557904 | Nivell -01 PS1_PK | VEN_EXT 6
1557929 | Nivell -01 PS1_PK | VEN_EXT 6
1557931 | Nivell -01 PS1_PK | VEN_EXT 6
1576018 | Nivell -01 PS1_PK | VEN_EXT 6
1576020 | Nivell -01 PS1_PK | VEN_EXT 6
1576077 | Nivell -01 PS1_PK | VEN_EXT 6
1576239 | Nivell -01 PS1_PK | VEN_EXT 6
1576244 | Nivell -01 PS1_PK | VEN_EXT 6
1579740 | Nivell -01 PS1_PK | VEN_EXT 6
1579767 | Nivell -01 PS1_PK | VEN_EXT 6
1579771 | Nivell -01 PS1_PK | VEN_EXT 6
1589686 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1589850 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1589858 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1589866 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1589917 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1590072 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1593104 | Nivell 07 P07_PP | VEN_EXT 35
1595983 | Nivell 07 P07_PP | VEN_EXT 1

# IfcFlowFitting: M_Codo vertical exterior de canal:EL (35)
Type - Material: <Unnamed>
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EL; sets with these values: 2
Name (M_Codo vertical exterior de canal:EL:...) | In | Group
1425160 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427698 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427759 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427820 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427881 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427942 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1451381 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1451411 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1451607 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1451612 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1451643 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1451648 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1451661 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1451666 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1451679 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1451684 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1451697 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1451702 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1452570 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1453066 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1453100 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1453117 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1453134 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1453151 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1455224 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1455283 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1455288 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1455293 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1455298 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1455303 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1491753 | Nivell 00 P00_PB
1496341 | Nivell 00 P00_PB
1528599 | Nivell -01 PS1_PK
1528603 | Nivell -01 PS1_PK
1591106 | Nivell 00 P00_PB

# IfcFlowFitting: M_Codo vertical exterior de canal:Gasos, M_Codo vertical exterior de canal:Gasos:1490421
In: Nivell 00 P00_PB
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Gasos; sets with these values: 2

# IfcFlowFitting: M_Codo vertical exterior de canal:SF (6)
Type - Material: <Unnamed>
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SF; sets with these values: 2
Name (M_Codo vertical exterior de canal:SF:...) | In | Group
1426215 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427708 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427769 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427830 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427891 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427952 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957

# IfcFlowFitting: M_Codo vertical interior de canal:EL (35)
Type - Material: <Unnamed>
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EL; sets with these values: 2
Name (M_Codo vertical interior de canal:EL:...) | In | Group
1451387 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1451389 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1451416 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1451608 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1451609 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
