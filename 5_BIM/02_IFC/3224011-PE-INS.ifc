Properties of the parts of a building model (IFC2X3), part 8 of 11

# IfcFlowFitting: M_Codo vertical interior de canal:EL (35)
Name (M_Codo vertical interior de canal:EL:...) | In | Group
1451613 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1451644 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1451645 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1451649 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1451662 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1451663 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1451667 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1451680 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1451681 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1451685 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1451698 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1451699 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1451703 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1452341 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1453065 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1453099 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1453116 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1453133 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1453150 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1455237 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1455284 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1455289 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1455294 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1455299 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1455304 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1492171 | Nivell 00 P00_PB
1492216 | Nivell 00 P00_PB
1496356 | Nivell 00 P00_PB
1528596 | Nivell -01 PS1_PK
1558922 | Nivell -01 PS1_PK

# IfcFlowFitting: M_Codo vertical interior de canal:Gasos, M_Codo vertical interior de canal:Gasos:1490496
In: Nivell 00 P00_PB
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Gasos; sets with these values: 2

# IfcFlowFitting: M_Codo vertical interior de canal:SF (6)
Type - Material: <Unnamed>
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SF; sets with these values: 2
Name (M_Codo vertical interior de canal:SF:...) | In | Group
1426309 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427711 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427772 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427833 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427894 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427955 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957

# IfcFlowFitting: M_Remate rectangular:EXT (3)
In: Nivell -01 PS1_PK
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT; sets with these values: 2
Name (M_Remate rectangular:EXT:...) | Group
1471182 | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1475894 | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475920 | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3

# IfcFlowFitting: M_Te - Genérica:Estándar (42)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (M_Te - Genérica:Estándar:...) | In | Group
1348628 | Nivell 07 P07_PP | 04_SN_APLU 2
1351322 | Nivell 07 P07_PP | 04_SN_APLU 3
1352343 | Nivell 07 P07_PP | 04_SN_APLU 4
1352945 | Nivell 04 P04_PP | 04_SN_APLU 6
1353129 | Nivell 04 P04_PP | 04_SN_APLU 13
1399543 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1416006 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
1434998 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1442858 | Nivell 06 P06_PP | 04_SN_APLU 3
1442912 | Nivell 06 P06_PP | 04_SN_APLU 1
1464286 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1464598 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1464617 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1464825 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1464967 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1482946 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1483546 | Nivell 00 P00_PB | 04_SN_AFEC 10
1486645 | Nivell 00 P00_PB | 11_CI_BIE 1
1503362 | Nivell -01 PS1_PK | 04_SN_AGRIS 7
1504325 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1505272 | Nivell 00 P00_PB | 04_SN_AGRIS 6
1506200 | Nivell -03 PS2_PK | 04_SN_AGRIS 4
1508488 | Nivell -03 PS2_PK | 04_SN_AFEC 24
1521115 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1521805 | Nivell -01 PS1_PK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
1521847 | Nivell -01 PS1_PK | 03_FN_AFS 4
1533029 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1536493 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1538846 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540164 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540529 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540546 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1547976 | Nivell -01 PS1_PK | 04_SN_APLU 9
1559615 | Nivell -01 PS1_PK | 04_SN_APLU 20
1564113 | Nivell -01 PS1_PK | 03_FN_AFS 4
1572896 | Nivell -01 PS1_PK | 03_FN_AFS 4
1577487 | Nivell -01 PS1_PK | 03_FN_AFS 4
1580854 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1586107 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1593930 | Nivell -01 PS1_PK | 04_SN_APLU 9
1594980 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_APLU 11
1595827 | Nivell -01 PS1_PK | 04_SN_ABOM 1; 04_SN_AFEC 18

# IfcFlowFitting: M_Te - Genérica:Estándar (13)
Type - Material: ARC_METALL_AN
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (M_Te - Genérica:Estándar:...) | In | Group
1407456 | Nivell 03 P03_PP | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4
1407484 | Nivell 02 P02_PP | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1
1407578 | Nivell 04 P04_PP | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6
1407835 | Nivell 00 P00_PB | 11_CI_BIE 1
1408379 | Nivell -01 PS1_PK | 11_CI_BIE 1
1408553 | Nivell -01 PS1_PK | 11_CI_BIE 1
1409886 | Nivell -01 PS1_PK | 11_CI_BIE 1
1487452 | Nivell 00 P00_PB | 11_CI_BIE 1
1514881 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1521561 | Nivell -01 PS1_PK | 11_CI_BIE 1
1551305 | Nivell 01 P01_PP | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2
1569293 | Nivell -01 PS1_PK | 17_XRX_1ria_REG 3
1575171 | Nivell -01 PS1_PK | 11_CI_BIE 1

# IfcFlowFitting: M_Te horizontal de canal:EL_Radio 300 mm (8)
Type - Material: <Unnamed>
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EL_Radio 300 mm; sets with these values: 2
Name (M_Te horizontal de canal:EL_Radio 300 mm:...) | In | Group
1425122 | Nivell 06 P06_PP | Model Group:08_FOR_SF P6:1427270
1427672 | Nivell 01 P01_PP | Model Group:08_FOR_SF P6:1427713
1427733 | Nivell 02 P02_PP | Model Group:08_FOR_SF P6:1427774
1427794 | Nivell 03 P03_PP | Model Group:08_FOR_SF P6:1427835
1427855 | Nivell 04 P04_PP | Model Group:08_FOR_SF P6:1427896
1427916 | Nivell 05 P05_PP | Model Group:08_FOR_SF P6:1427957
1495679 | Nivell 00 P00_PB
1496168 | Nivell 00 P00_PB

# IfcFlowFitting: M_Te rectangular:APT (7)
Type - Material: <Unnamed>
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: APT; sets with these values: 2
Name (M_Te rectangular:APT:...) | In | Group
1343879 | Nivell 06 P06_PP | Model Group:05_VEN_Distribució planta:1344090; VEN_APT 3
1344354 | Nivell 01 P01_PP | Model Group:05_VEN_Distribució planta:1344381; VEN_APT 5
1344394 | Nivell 02 P02_PP | Model Group:05_VEN_Distribució planta:1344421; VEN_APT 10
1344434 | Nivell 03 P03_PP | Model Group:05_VEN_Distribució planta:1344461; VEN_APT 13
1344474 | Nivell 04 P04_PP | Model Group:05_VEN_Distribució planta:1344501; VEN_APT 16
1344514 | Nivell 05 P05_PP | Model Group:05_VEN_Distribució planta:1344541; VEN_APT 19
1498567 | Nivell -01 PS1_PK | VEN_APT 6

# IfcFlowFitting: M_Te rectangular:EXT (12)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT; sets with these values: 2
Name (M_Te rectangular:EXT:...) | In | Group
1480570 | Nivell 06 P06_PP | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1480636 | Nivell 06 P06_PP | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1480789 | Nivell 04 P04_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1480792 | Nivell 04 P04_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_IMP 5
1480989 | Nivell 01 P01_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1480992 | Nivell 01 P01_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_IMP 6
1481009 | Nivell 02 P02_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481012 | Nivell 02 P02_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_IMP 10
1481029 | Nivell 03 P03_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481032 | Nivell 03 P03_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_IMP 13
1481049 | Nivell 05 P05_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1481052 | Nivell 05 P05_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_IMP 16

# IfcFlowFitting: M_Toma de derivación rectangular:EXT (7)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT; sets with these values: 2
Name (M_Toma de derivación rectangular:EXT:...) | In | Group
1343340 | Nivell 08 P08_PC | VEN_APT 4
1343449 | Nivell 08 P08_PC | VEN_APT 1
1471232 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1471264; CLI_RET 1
1474918 | Nivell 00 P00_PB | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_RET 4
1475897 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475899; CLI_RET 2
1475923 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475925; CLI_RET 3
1518898 | Nivell -01 PS1_PK | VEN_EXT 7

# IfcFlowFitting: M_Toma de derivación redonda:EXT (25)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT; sets with these values: 2
Name (M_Toma de derivación redonda:EXT:...) | In | Group
1439209 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1439368 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1439688 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1439726 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1439921 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1439959 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1447367 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1447373 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1447384 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1447390 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1447437 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1447443 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1447454 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1447460 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1476649 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476651 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476812 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1476814 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1579764 | Nivell -01 PS1_PK | VEN_EXT 6
1589683 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1589848 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1589856 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1589864 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1589915 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1590070 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28

# IfcFlowFitting: M_Transición - Genérica:Estándar (42)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (M_Transición - Genérica:Estándar:...) | In | Group
1338689 | Nivell 08 P08_PC | 04_SN_APLU 1
1339530 | Nivell 08 P08_PC | 04_SN_APLU 3
1346917 | Nivell 07 P07_PP | 04_SN_APLU 11
1347437 | Nivell 08 P08_PC | 04_SN_APLU 3
1347450 | Nivell 08 P08_PC | 04_SN_APLU 3
1347471 | Nivell 07 P07_PP | 04_SN_APLU 8
1347510 | Nivell 07 P07_PP | 04_SN_APLU 3
1348717 | Nivell 07 P07_PP | 04_SN_APLU 2
1350344 | Nivell 05 P05_PP | 04_SN_APLU 5
1350548 | Nivell 05 P05_PP | 04_SN_APLU 12
1351534 | Nivell 08 P08_PC | 04_SN_APLU 2
1352326 | Nivell 08 P08_PC | 04_SN_APLU 4
1352337 | Nivell 08 P08_PC | 04_SN_APLU 4
1352742 | Nivell 04 P04_PP | 04_SN_APLU 6
1352873 | Nivell 03 P03_PP | 04_SN_APLU 7
1352898 | Nivell 04 P04_PP | 04_SN_APLU 6
1353114 | Nivell 04 P04_PP | 04_SN_APLU 13
1353116 | Nivell 03 P03_PP | 04_SN_APLU 15
1353127 | Nivell 04 P04_PP | 04_SN_APLU 13
1367600 | Nivell 06 P06_PP | 04_SN_AFEC 1
1443102 | Nivell 07 P07_PP | 04_SN_APLU 1
1482788 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1482952 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1483554 | Nivell 00 P00_PB | 04_SN_AFEC 10
1504334 | Nivell -01 PS1_PK | 04_SN_AFEC 9
1506730 | Nivell -01 PS1_PK | 04_SN_AFEC 24
1533033 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1536497 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AGRIS 8
1538855 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540022 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540538 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1540554 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1558321 | Nivell 00 P00_PB | 04_SN_AFEC 16
1577492 | Nivell -01 PS1_PK | 03_FN_AFS 4
1585714 | Nivell -01 PS1_PK | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1586115 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 18
1594151 | Nivell 00 P00_PB | Model Group:04_SN_Planta tipus PB:1374208; 04_SN_AFEC 20
1594265 | Nivell 07 P07_PP | 04_SN_APLU 17
1594376 | Nivell -01 PS1_PK | 04_SN_APLU 9
1594385 | Nivell -01 PS1_PK | 04_SN_APLU 9
1594387 | Nivell -01 PS1_PK | 04_SN_APLU 9
1595059 | Nivell 06 P06_PP | 04_SN_APLU 11

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:EXT_45 graus (2)
In: Nivell 06 P06_PP
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_45 graus; sets with these values: 2
Name (M_Transición de rectangular a redondo - Ángulo:EXT_45 graus:...) | Group
1445124 | VEN_EXT 3
1453409 | VEN_EXT 5

# IfcFlowFitting: M_Transición rectangular - Ángulo:APT_45 graus (6)
Type - Material: <Unnamed>
Classification: 50.30.40.10 Aportació de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: APT_45 graus; sets with these values: 2
Name (M_Transición rectangular - Ángulo:APT_45 graus:...) | In | Group
1456172 | Nivell 07 P07_PP | VEN_APT 2
1468566 | Nivell 07 P07_PP | VEN_EXT 2
1485150 | Nivell 00 P00_PB | VEN_APT 8
1485350 | Nivell 00 P00_PB | VEN_APT 8
1498569 | Nivell -01 PS1_PK | VEN_APT 6
1498653 | Nivell -01 PS1_PK | VEN_APT 6

# IfcFlowFitting: M_Transición rectangular - Ángulo:EXT_45 graus (21)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_45 graus; sets with these values: 2
Name (M_Transición rectangular - Ángulo:EXT_45 graus:...) | In | Group
1441009 | Nivell 07 P07_PP | VEN_EXT 5
1445452 | Nivell 07 P07_PP | VEN_EXT 3
1474869 | Nivell 00 P00_PB | Model Group:05_CA_FC2_PB Vestíbul:1479398; CLI_IMP 4
1475640 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1471264; CLI_IMP 1
1475900 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475899; CLI_IMP 2
1475926 | Nivell -01 PS1_PK | Model Group:05_CLI_FC01_PS1:1475925; CLI_IMP 3
1481080 | Nivell 04 P04_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_IMP 5
1481081 | Nivell 04 P04_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480780; CLI_RET 5
1481193 | Nivell 01 P01_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_IMP 6
1481194 | Nivell 01 P01_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1480984; CLI_RET 6
1481202 | Nivell 02 P02_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_IMP 10
1481203 | Nivell 02 P02_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481004; CLI_RET 10
1481211 | Nivell 03 P03_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_IMP 13
1481212 | Nivell 03 P03_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481024; CLI_RET 13
1481220 | Nivell 05 P05_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_IMP 16
1481221 | Nivell 05 P05_PP | Model Group:05_CA_FC1_Ptipus Vestíbul:1481044; CLI_RET 16
1481247 | Nivell 06 P06_PP | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_IMP 8
1481248 | Nivell 06 P06_PP | Model Group:05_CA_FC2_P6 Vestíbul:1480209; CLI_RET 9
1485149 | Nivell 00 P00_PB | VEN_EXT 8
1485349 | Nivell 00 P00_PB | VEN_EXT 8
1498770 | Nivell -01 PS1_PK | VEN_EXT 7

# IfcFlowFitting: M_Transición redonda - Ángulo:EXT_45 graus (13)
Type - Material: <Unnamed>
Classification: 50.30.40.20 Extracció de aire primari (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EXT_45 graus; sets with these values: 2
Name (M_Transición redonda - Ángulo:EXT_45 graus:...) | In | Group
1458467 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1437633; VEN_EXT 26
1458868 | Nivell 05 P05_PP | Model Group:05_VEN_Extr banys tipus:1439351; VEN_EXT 18
1458886 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439671; VEN_EXT 38
1458904 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439709; VEN_EXT 42
1458922 | Nivell 04 P04_PP | Model Group:05_VEN_Extr banys tipus:1439904; VEN_EXT 43
1458940 | Nivell 06 P06_PP | Model Group:05_VEN_Extr banys tipus:1439942; VEN_EXT 47
1459042 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446859; VEN_EXT 33
1459291 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439557; VEN_EXT 20
1459307 | Nivell 02 P02_PP | Model Group:05_VEN_Extr banys tipus inferiors:1439595; VEN_EXT 32
1459339 | Nivell 01 P01_PP | Model Group:05_VEN_Extr banys tipus inferiors:1446858; VEN_EXT 22
1476655 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1447555; VEN_EXT 28
1476818 | Nivell 03 P03_PP | Model Group:05_VEN_Extr banys tipus P3:1439633; VEN_EXT 37
1576241 | Nivell -01 PS1_PK | VEN_EXT 6

# IfcFlowFitting: M_Unión rectangular:APT, M_Unión rectangular:APT:1498745
In: Nivell -01 PS1_PK
Type - Material: <Unnamed>
Classification: 50.30.40.10 Aportació de aire primari (Uniformat); Group: VEN_APT 6
Pset_DistributionFlowElementCommon - Reference: APT; sets with these values: 2

# IfcFlowFitting: Reduccion Soldadura a Tope SDR 11 BluePipe - 250:Estándar (2)
In: Nivell -01 PS1_PK
Type - Material: Fuisiolen PP-R BLUE
Type - Pset_ManufacturerTypeInformation - Manufacturer: AQUATHERM
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (Reduccion Soldadura a Tope SDR 11 BluePipe - 250:Estándar:...) | Group
1595642 | 05_CA_AF_RET 15
1595644 | 05_CA_AF_IMP 9

# IfcFlowFitting: T-Soldadura a enchufe:Estándar (34)
Type - Material: Fuisiolen PP-R
Type - Pset_ManufacturerTypeInformation - Manufacturer: AQUATHERM
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (T-Soldadura a enchufe:Estándar:...) | In | Group
1389495 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389535 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389575 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389615 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1390056 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390066 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390076 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390086 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390199 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390209 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390219 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390229 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390342 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390352 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390362 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390372 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390485 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390495 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390505 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390515 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390628 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390638 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390648 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390658 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1467563 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1467585 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1467595 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1467639 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494252 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_RET 10
1494303 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AF_IMP 10
1494357 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_RET 10
1494412 | Nivell 00 P00_PB | Model Group:05_CA_Pipes PB:1396311; 05_CA_AC_IMP 10
1571628 | Nivell -01 PS1_PK | 05_CA_AC_IMP 12
1571637 | Nivell -01 PS1_PK | 05_CA_AC_RET 12

# IfcFlowSegment: Cable Tray with Fittings:EL (185)
Type - PredefinedType: CABLETRAYSEGMENT
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: EL; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:EL:...) | In | Length (m) | Group
1425092 | Nivell 00 P00_PB | 2.01005
1425093 | Nivell 06 P06_PP | 22.0482
1425098 | Nivell 06 P06_PP | 1.37147 | Model Group:08_FOR_SF P6:1427270
1425099 | Nivell 06 P06_PP | 11.9567 | Model Group:08_FOR_SF P6:1427270
1425103 | Nivell 06 P06_PP | 10.9314 | Model Group:08_FOR_SF P6:1427270
1425106 | Nivell 06 P06_PP | 0.374 | Model Group:08_FOR_SF P6:1427270
1425107 | Nivell 06 P06_PP | 2.3776 | Model Group:08_FOR_SF P6:1427270
1425115 | Nivell 06 P06_PP | 1.98038 | Model Group:08_FOR_SF P6:1427270
1425127 | Nivell 06 P06_PP | 0.675 | Model Group:08_FOR_SF P6:1427270
1425128 | Nivell 06 P06_PP | 2.0786 | Model Group:08_FOR_SF P6:1427270
1425133 | Nivell 06 P06_PP | 3.02927 | Model Group:08_FOR_SF P6:1427270
1425147 | Nivell 06 P06_PP | 9.2 | Model Group:08_FOR_SF P6:1427270
1425159 | Nivell 06 P06_PP | 0.10273 | Model Group:08_FOR_SF P6:1427270
1425163 | Nivell 06 P06_PP | 10.55 | Model Group:08_FOR_SF P6:1427270
1425171 | Nivell 06 P06_PP | 18.475
1425359 | Nivell 06 P06_PP | 1.64 | Model Group:08_FOR_SF P6:1427270
1425431 | Nivell 06 P06_PP | 0.925 | Model Group:08_FOR_SF P6:1427270
1427655 | Nivell 01 P01_PP | 1.37147 | Model Group:08_FOR_SF P6:1427713
1427656 | Nivell 01 P01_PP | 11.9567 | Model Group:08_FOR_SF P6:1427713
1427659 | Nivell 01 P01_PP | 10.9314 | Model Group:08_FOR_SF P6:1427713
1427662 | Nivell 01 P01_PP | 0.374 | Model Group:08_FOR_SF P6:1427713
1427663 | Nivell 01 P01_PP | 2.3776 | Model Group:08_FOR_SF P6:1427713
1427668 | Nivell 01 P01_PP | 1.98038 | Model Group:08_FOR_SF P6:1427713
1427674 | Nivell 01 P01_PP | 0.675 | Model Group:08_FOR_SF P6:1427713
1427675 | Nivell 01 P01_PP | 2.0786 | Model Group:08_FOR_SF P6:1427713
1427680 | Nivell 01 P01_PP | 3.02927 | Model Group:08_FOR_SF P6:1427713
1427688 | Nivell 01 P01_PP | 9.2 | Model Group:08_FOR_SF P6:1427713
1427697 | Nivell 01 P01_PP | 0.10273 | Model Group:08_FOR_SF P6:1427713
1427700 | Nivell 01 P01_PP | 10.55 | Model Group:08_FOR_SF P6:1427713
1427705 | Nivell 01 P01_PP | 1.64 | Model Group:08_FOR_SF P6:1427713
1427706 | Nivell 01 P01_PP | 0.925 | Model Group:08_FOR_SF P6:1427713
1427716 | Nivell 02 P02_PP | 1.37147 | Model Group:08_FOR_SF P6:1427774
1427717 | Nivell 02 P02_PP | 11.9567 | Model Group:08_FOR_SF P6:1427774
1427720 | Nivell 02 P02_PP | 10.9314 | Model Group:08_FOR_SF P6:1427774
1427723 | Nivell 02 P02_PP | 0.374 | Model Group:08_FOR_SF P6:1427774
1427724 | Nivell 02 P02_PP | 2.3776 | Model Group:08_FOR_SF P6:1427774
1427729 | Nivell 02 P02_PP | 1.98038 | Model Group:08_FOR_SF P6:1427774
1427735 | Nivell 02 P02_PP | 0.675 | Model Group:08_FOR_SF P6:1427774
1427736 | Nivell 02 P02_PP | 2.0786 | Model Group:08_FOR_SF P6:1427774
1427741 | Nivell 02 P02_PP | 3.02927 | Model Group:08_FOR_SF P6:1427774
1427749 | Nivell 02 P02_PP | 9.2 | Model Group:08_FOR_SF P6:1427774
1427758 | Nivell 02 P02_PP | 0.10273 | Model Group:08_FOR_SF P6:1427774
1427761 | Nivell 02 P02_PP | 10.55 | Model Group:08_FOR_SF P6:1427774
1427766 | Nivell 02 P02_PP | 1.64 | Model Group:08_FOR_SF P6:1427774
1427767 | Nivell 02 P02_PP | 0.925 | Model Group:08_FOR_SF P6:1427774
1427777 | Nivell 03 P03_PP | 1.37147 | Model Group:08_FOR_SF P6:1427835
1427778 | Nivell 03 P03_PP | 11.9567 | Model Group:08_FOR_SF P6:1427835
1427781 | Nivell 03 P03_PP | 10.9314 | Model Group:08_FOR_SF P6:1427835
1427784 | Nivell 03 P03_PP | 0.374 | Model Group:08_FOR_SF P6:1427835
1427785 | Nivell 03 P03_PP | 2.3776 | Model Group:08_FOR_SF P6:1427835
1427790 | Nivell 03 P03_PP | 1.98038 | Model Group:08_FOR_SF P6:1427835
1427796 | Nivell 03 P03_PP | 0.675 | Model Group:08_FOR_SF P6:1427835
1427797 | Nivell 03 P03_PP | 2.0786 | Model Group:08_FOR_SF P6:1427835
1427802 | Nivell 03 P03_PP | 3.02927 | Model Group:08_FOR_SF P6:1427835
1427810 | Nivell 03 P03_PP | 9.2 | Model Group:08_FOR_SF P6:1427835
1427819 | Nivell 03 P03_PP | 0.10273 | Model Group:08_FOR_SF P6:1427835
1427822 | Nivell 03 P03_PP | 10.55 | Model Group:08_FOR_SF P6:1427835
1427827 | Nivell 03 P03_PP | 1.64 | Model Group:08_FOR_SF P6:1427835
1427828 | Nivell 03 P03_PP | 0.925 | Model Group:08_FOR_SF P6:1427835
1427838 | Nivell 04 P04_PP | 1.37147 | Model Group:08_FOR_SF P6:1427896
1427839 | Nivell 04 P04_PP | 11.9567 | Model Group:08_FOR_SF P6:1427896
1427842 | Nivell 04 P04_PP | 10.9314 | Model Group:08_FOR_SF P6:1427896
1427845 | Nivell 04 P04_PP | 0.374 | Model Group:08_FOR_SF P6:1427896
1427846 | Nivell 04 P04_PP | 2.3776 | Model Group:08_FOR_SF P6:1427896
1427851 | Nivell 04 P04_PP | 1.98038 | Model Group:08_FOR_SF P6:1427896
1427857 | Nivell 04 P04_PP | 0.675 | Model Group:08_FOR_SF P6:1427896
1427858 | Nivell 04 P04_PP | 2.0786 | Model Group:08_FOR_SF P6:1427896
1427863 | Nivell 04 P04_PP | 3.02927 | Model Group:08_FOR_SF P6:1427896
1427871 | Nivell 04 P04_PP | 9.2 | Model Group:08_FOR_SF P6:1427896
1427880 | Nivell 04 P04_PP | 0.10273 | Model Group:08_FOR_SF P6:1427896
1427883 | Nivell 04 P04_PP | 10.55 | Model Group:08_FOR_SF P6:1427896
1427888 | Nivell 04 P04_PP | 1.64 | Model Group:08_FOR_SF P6:1427896
1427889 | Nivell 04 P04_PP | 0.925 | Model Group:08_FOR_SF P6:1427896
1427899 | Nivell 05 P05_PP | 1.37147 | Model Group:08_FOR_SF P6:1427957
1427900 | Nivell 05 P05_PP | 11.9567 | Model Group:08_FOR_SF P6:1427957
1427903 | Nivell 05 P05_PP | 10.9314 | Model Group:08_FOR_SF P6:1427957
1427906 | Nivell 05 P05_PP | 0.374 | Model Group:08_FOR_SF P6:1427957
1427907 | Nivell 05 P05_PP | 2.3776 | Model Group:08_FOR_SF P6:1427957
1427912 | Nivell 05 P05_PP | 1.98038 | Model Group:08_FOR_SF P6:1427957
1427918 | Nivell 05 P05_PP | 0.675 | Model Group:08_FOR_SF P6:1427957
1427919 | Nivell 05 P05_PP | 2.0786 | Model Group:08_FOR_SF P6:1427957
1427924 | Nivell 05 P05_PP | 3.02927 | Model Group:08_FOR_SF P6:1427957
1427932 | Nivell 05 P05_PP | 9.2 | Model Group:08_FOR_SF P6:1427957
1427941 | Nivell 05 P05_PP | 0.10273 | Model Group:08_FOR_SF P6:1427957
1427944 | Nivell 05 P05_PP | 10.55 | Model Group:08_FOR_SF P6:1427957
1427949 | Nivell 05 P05_PP | 1.64 | Model Group:08_FOR_SF P6:1427957
1427950 | Nivell 05 P05_PP | 0.925 | Model Group:08_FOR_SF P6:1427957
1429089 | Nivell 00 P00_PB | 8.03721
1429101 | Nivell 00 P00_PB | 6.79915
1429126 | Nivell 00 P00_PB | 10.0378
1429478 | Nivell -01 PS1_PK | 15.1224
1430133 | Nivell -01 PS1_PK | 18.9924
1431574 | Nivell -01 PS1_PK | 13.8761
1451084 | Nivell 03 P03_PP | 20.4831 | Model Group:08_FOR_SF P6:1427835
1451248 | Nivell 06 P06_PP | 20.4831 | Model Group:08_FOR_SF P6:1427270
1451258 | Nivell 01 P01_PP | 20.4831 | Model Group:08_FOR_SF P6:1427713
1451263 | Nivell 02 P02_PP | 20.4831 | Model Group:08_FOR_SF P6:1427774
1451268 | Nivell 04 P04_PP | 20.4831 | Model Group:08_FOR_SF P6:1427896
1451273 | Nivell 05 P05_PP | 20.4831 | Model Group:08_FOR_SF P6:1427957
1451379 | Nivell 03 P03_PP | 3.03833 | Model Group:08_FOR_SF P6:1427835
1451380 | Nivell 03 P03_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427835
1451409 | Nivell 03 P03_PP | 3.36757 | Model Group:08_FOR_SF P6:1427835
1451410 | Nivell 03 P03_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427835
1451605 | Nivell 06 P06_PP | 3.03833 | Model Group:08_FOR_SF P6:1427270
1451606 | Nivell 06 P06_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427270
1451610 | Nivell 06 P06_PP | 3.36757 | Model Group:08_FOR_SF P6:1427270
1451611 | Nivell 06 P06_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427270
1451641 | Nivell 01 P01_PP | 3.03833 | Model Group:08_FOR_SF P6:1427713
1451642 | Nivell 01 P01_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427713
1451646 | Nivell 01 P01_PP | 3.36757 | Model Group:08_FOR_SF P6:1427713
1451647 | Nivell 01 P01_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427713
1451659 | Nivell 02 P02_PP | 3.03833 | Model Group:08_FOR_SF P6:1427774
1451660 | Nivell 02 P02_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427774
1451664 | Nivell 02 P02_PP | 3.36757 | Model Group:08_FOR_SF P6:1427774
1451665 | Nivell 02 P02_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427774
1451677 | Nivell 04 P04_PP | 3.03833 | Model Group:08_FOR_SF P6:1427896
1451678 | Nivell 04 P04_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427896
1451682 | Nivell 04 P04_PP | 3.36757 | Model Group:08_FOR_SF P6:1427896
1451683 | Nivell 04 P04_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427896
1451695 | Nivell 05 P05_PP | 3.03833 | Model Group:08_FOR_SF P6:1427957
1451696 | Nivell 05 P05_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427957
1451700 | Nivell 05 P05_PP | 3.36757 | Model Group:08_FOR_SF P6:1427957
1451701 | Nivell 05 P05_PP | 0.0624356 | Model Group:08_FOR_SF P6:1427957
1452339 | Nivell 02 P02_PP | 20.4831 | Model Group:08_FOR_SF P6:1427774
1452340 | Nivell 02 P02_PP | 0.10273 | Model Group:08_FOR_SF P6:1427774
1452764 | Nivell 02 P02_PP | 3.7662 | Model Group:08_FOR_SF P6:1427774
1452801 | Nivell 02 P02_PP | 3.20038 | Model Group:08_FOR_SF P6:1427774
1453063 | Nivell 06 P06_PP | 20.4831 | Model Group:08_FOR_SF P6:1427270
1453064 | Nivell 06 P06_PP | 0.10273 | Model Group:08_FOR_SF P6:1427270
1453067 | Nivell 06 P06_PP | 3.7662 | Model Group:08_FOR_SF P6:1427270
1453072 | Nivell 06 P06_PP | 3.20038 | Model Group:08_FOR_SF P6:1427270
1453097 | Nivell 01 P01_PP | 20.4831 | Model Group:08_FOR_SF P6:1427713
1453098 | Nivell 01 P01_PP | 0.10273 | Model Group:08_FOR_SF P6:1427713
1453101 | Nivell 01 P01_PP | 3.7662 | Model Group:08_FOR_SF P6:1427713
1453106 | Nivell 01 P01_PP | 3.20038 | Model Group:08_FOR_SF P6:1427713
1453114 | Nivell 03 P03_PP | 20.4831 | Model Group:08_FOR_SF P6:1427835
1453115 | Nivell 03 P03_PP | 0.10273 | Model Group:08_FOR_SF P6:1427835
1453118 | Nivell 03 P03_PP | 3.7662 | Model Group:08_FOR_SF P6:1427835
1453123 | Nivell 03 P03_PP | 3.20038 | Model Group:08_FOR_SF P6:1427835
1453131 | Nivell 04 P04_PP | 20.4831 | Model Group:08_FOR_SF P6:1427896
1453132 | Nivell 04 P04_PP | 0.10273 | Model Group:08_FOR_SF P6:1427896
1453135 | Nivell 04 P04_PP | 3.7662 | Model Group:08_FOR_SF P6:1427896
1453140 | Nivell 04 P04_PP | 3.20038 | Model Group:08_FOR_SF P6:1427896
1453148 | Nivell 05 P05_PP | 20.4831 | Model Group:08_FOR_SF P6:1427957
1453149 | Nivell 05 P05_PP | 0.10273 | Model Group:08_FOR_SF P6:1427957
1453152 | Nivell 05 P05_PP | 3.7662 | Model Group:08_FOR_SF P6:1427957
1453157 | Nivell 05 P05_PP | 3.20038 | Model Group:08_FOR_SF P6:1427957
1455131 | Nivell 06 P06_PP | 6.00646 | Model Group:08_FOR_SF P6:1427270
1455223 | Nivell 06 P06_PP | 0.10273 | Model Group:08_FOR_SF P6:1427270
1455281 | Nivell 01 P01_PP | 6.00646 | Model Group:08_FOR_SF P6:1427713
1455282 | Nivell 01 P01_PP | 0.10273 | Model Group:08_FOR_SF P6:1427713
1455286 | Nivell 02 P02_PP | 6.00646 | Model Group:08_FOR_SF P6:1427774
1455287 | Nivell 02 P02_PP | 0.10273 | Model Group:08_FOR_SF P6:1427774
1455291 | Nivell 03 P03_PP | 6.00646 | Model Group:08_FOR_SF P6:1427835
1455292 | Nivell 03 P03_PP | 0.10273 | Model Group:08_FOR_SF P6:1427835
1455296 | Nivell 04 P04_PP | 6.00646 | Model Group:08_FOR_SF P6:1427896
1455297 | Nivell 04 P04_PP | 0.10273 | Model Group:08_FOR_SF P6:1427896
1455301 | Nivell 05 P05_PP | 6.00646 | Model Group:08_FOR_SF P6:1427957
1455302 | Nivell 05 P05_PP | 0.10273 | Model Group:08_FOR_SF P6:1427957
1489000 | Nivell 00 P00_PB | 5.83722
1489008 | Nivell 00 P00_PB | 32.376
1489991 | Nivell 00 P00_PB | 32.376
1491676 | Nivell 00 P00_PB | 5.31801
1491751 | Nivell 00 P00_PB | 5.83722
1491752 | Nivell 00 P00_PB | 0.0160254
1491794 | Nivell 00 P00_PB | 5.31801
1491795 | Nivell 00 P00_PB | 0.0160254
1492083 | Nivell 00 P00_PB | 1.01179
1495680 | Nivell 00 P00_PB | 0.0628329
1496067 | Nivell 00 P00_PB | 7.56477
1496071 | Nivell 00 P00_PB | 9.625
1496270 | Nivell 00 P00_PB | 0.478052
1496339 | Nivell 00 P00_PB | 3.54526
1496340 | Nivell 00 P00_PB | 0.32122
1515732 | Nivell -01 PS1_PK | 3.72
1517880 | Nivell -01 PS1_PK | 0.0859174
1527388 | Nivell -01 PS1_PK | 13.6261
1528555 | Nivell -01 PS1_PK | 15.7474
1528556 | Nivell -01 PS1_PK | 18.8174
1528557 | Nivell -01 PS1_PK | 1.22408
1528558 | Nivell -01 PS1_PK | 0.974083
1528559 | Nivell -01 PS1_PK | 2.92
1528560 | Nivell -01 PS1_PK | 0.0859174
1528561 | Nivell -01 PS1_PK | 0.7
1528564 | Nivell -01 PS1_PK | 0.65

# IfcFlowSegment: Cable Tray with Fittings:Gasos (5)
In: Nivell 00 P00_PB
Type - PredefinedType: CABLETRAYSEGMENT
Classification: 50.60.30.10 Safates de distribució elèctrica (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Gasos; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Gasos:...) | Length (m)
1490305 | 3.16787
1490411 | 0.0792893
1490425 | 0.797817
1490500 | 1.4
1491840 | 3.425

# IfcFlowSegment: Cable Tray with Fittings:SF (31)
Type - PredefinedType: CABLETRAYSEGMENT
Classification: 50.70.30.10 Safates de distribució per a senyals dèbils (Uniformat)
Pset_DistributionFlowElementCommon - Reference: SF; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:SF:...) | In | Length (m) | Group
1425086 | Nivell 07 P07_PP | 15.275
1425087 | Nivell 07 P07_PP | 19.25
1425090 | Nivell 07 P07_PP | 20.875
1425265 | Nivell 06 P06_PP | 18.475
1425347 | Nivell 06 P06_PP | 1.12515 | Model Group:08_FOR_SF P6:1427270
1425348 | Nivell 06 P06_PP | 0.945 | Model Group:08_FOR_SF P6:1427270
1426235 | Nivell 06 P06_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427270
1426243 | Nivell 06 P06_PP | 0.640147 | Model Group:08_FOR_SF P6:1427270
1427015 | Nivell 06 P06_PP | 11.1432
1427702 | Nivell 01 P01_PP | 1.12515 | Model Group:08_FOR_SF P6:1427713
1427703 | Nivell 01 P01_PP | 0.945 | Model Group:08_FOR_SF P6:1427713
1427709 | Nivell 01 P01_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427713
1427710 | Nivell 01 P01_PP | 0.640147 | Model Group:08_FOR_SF P6:1427713
1427763 | Nivell 02 P02_PP | 1.12515 | Model Group:08_FOR_SF P6:1427774
1427764 | Nivell 02 P02_PP | 0.945 | Model Group:08_FOR_SF P6:1427774
1427770 | Nivell 02 P02_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427774
1427771 | Nivell 02 P02_PP | 0.640147 | Model Group:08_FOR_SF P6:1427774
1427824 | Nivell 03 P03_PP | 1.12515 | Model Group:08_FOR_SF P6:1427835
1427825 | Nivell 03 P03_PP | 0.945 | Model Group:08_FOR_SF P6:1427835
1427831 | Nivell 03 P03_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427835
1427832 | Nivell 03 P03_PP | 0.640147 | Model Group:08_FOR_SF P6:1427835
1427885 | Nivell 04 P04_PP | 1.12515 | Model Group:08_FOR_SF P6:1427896
1427886 | Nivell 04 P04_PP | 0.945 | Model Group:08_FOR_SF P6:1427896
1427892 | Nivell 04 P04_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427896
1427893 | Nivell 04 P04_PP | 0.640147 | Model Group:08_FOR_SF P6:1427896
1427946 | Nivell 05 P05_PP | 1.12515 | Model Group:08_FOR_SF P6:1427957
1427947 | Nivell 05 P05_PP | 0.945 | Model Group:08_FOR_SF P6:1427957
1427953 | Nivell 05 P05_PP | 0.0702944 | Model Group:08_FOR_SF P6:1427957
1427954 | Nivell 05 P05_PP | 0.640147 | Model Group:08_FOR_SF P6:1427957
1429308 | Nivell 06 P06_PP | 4.12
1515697 | Nivell 06 P06_PP | 4.12

# IfcFlowSegment: Pipe Types:AN_CI (203)
Classification: 50.50.10.50 Canalitzacions d'extinció d'incendis (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AN_CI; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:AN_CI:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1404044 | Nivell 06 P06_PP | 20.244 | 10.5716 | 11_CI_BIE 1
1404064 | Nivell 06 P06_PP | 28.3284 | 4.83 | 11_CI_RUIX 3 | Material: ARC_METALL_AN
1405126 | Nivell 06 P06_PP | 19.9 | 10.9156 | 11_CI_BIE 2
1405142 | Nivell 06 P06_PP | 18.38 | 12.4356 | 11_CI_BIE 3
1405158 | Nivell 06 P06_PP | 9.07698 | 10.9156 | 11_CI_BIE 4
1405160 | Nivell 06 P06_PP | 9.07698 | 10.9156 | 11_CI_BIE 5
1405650 | Nivell 06 P06_PP | 0.227613 | 30.7673 | Model Group:11_CI_Planta tipus:1406452; 11_CI_BIE 6
1405662 | Nivell 06 P06_PP | 0.167613 | 30.7673 | Model Group:11_CI_Planta tipus:1406452; 11_CI_BIE 6
1405689 | Nivell 06 P06_PP | 0.125913 | 32.9965 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1405701 | Nivell 06 P06_PP | 0.375913 | 32.9965 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1405724 | Nivell 06 P06_PP | 5.23936 | 33.1681 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1405734 | Nivell 06 P06_PP | 2.74761 | 33.1681 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1406356 | Nivell 06 P06_PP | 0.227613 | 30.7673 | Model Group:11_CI_Planta tipus:1406452; 11_CI_BIE 7
1406414 | Nivell 06 P06_PP | 0.227613 | 30.7673 | Model Group:11_CI_Planta tipus:1406452; 11_CI_BIE 8
1406528 | Nivell 03 P03_PP | 0.227613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 13
1406530 | Nivell 03 P03_PP | 0.167613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 13
1406534 | Nivell 03 P03_PP | 0.125913 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1406536 | Nivell 03 P03_PP | 0.419563 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1406544 | Nivell 03 P03_PP | 5.28936 | 21.9181 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1406548 | Nivell 03 P03_PP | 2.74761 | 21.9181 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1406552 | Nivell 03 P03_PP | 0.227613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 15
1406554 | Nivell 03 P03_PP | 0.227613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 16
1406564 | Nivell 04 P04_PP | 0.227613 | 23.2673 | Model Group:11_CI_P4:1407536; 11_CI_BIE 17
1406566 | Nivell 04 P04_PP | 0.167613 | 23.2673 | Model Group:11_CI_P4:1407536; 11_CI_BIE 17
1406570 | Nivell 04 P04_PP | 0.125913 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1406572 | Nivell 04 P04_PP | 0.419563 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1406580 | Nivell 04 P04_PP | 5.28936 | 25.6681 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1406584 | Nivell 04 P04_PP | 2.74761 | 25.6681 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1406588 | Nivell 04 P04_PP | 0.227613 | 23.2673 | Model Group:11_CI_P4:1407536; 11_CI_BIE 19
1406590 | Nivell 04 P04_PP | 0.227613 | 23.2673 | Model Group:11_CI_P4:1407536; 11_CI_BIE 20
1406600 | Nivell 05 P05_PP | 0.227613 | 27.0173 | Model Group:11_CI_Planta tipus:1406628; 11_CI_BIE 21
1406602 | Nivell 05 P05_PP | 0.167613 | 27.0173 | Model Group:11_CI_Planta tipus:1406628; 11_CI_BIE 21
1406606 | Nivell 05 P05_PP | 0.125913 | 29.2465 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1406608 | Nivell 05 P05_PP | 0.375913 | 29.2465 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1406616 | Nivell 05 P05_PP | 5.23936 | 29.4181 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1406620 | Nivell 05 P05_PP | 2.74761 | 29.4181 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1406624 | Nivell 05 P05_PP | 0.227613 | 27.0173 | Model Group:11_CI_Planta tipus:1406628; 11_CI_BIE 23
1406626 | Nivell 05 P05_PP | 0.227613 | 27.0173 | Model Group:11_CI_Planta tipus:1406628; 11_CI_BIE 24
1407016 | Nivell 03 P03_PP | 0.227613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 10
1407018 | Nivell 03 P03_PP | 0.227613 | 19.5173 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_BIE 14
1407269 | Nivell 02 P02_PP | 0.227613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 9
1407271 | Nivell 02 P02_PP | 0.167613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 9
1407275 | Nivell 02 P02_PP | 0.125913 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407277 | Nivell 02 P02_PP | 0.419563 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407285 | Nivell 02 P02_PP | 5.28936 | 18.1681 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407289 | Nivell 02 P02_PP | 2.74761 | 18.1681 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407293 | Nivell 02 P02_PP | 0.227613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 12
1407295 | Nivell 02 P02_PP | 0.227613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 22
1407297 | Nivell 02 P02_PP | 0.227613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 29
1407299 | Nivell 02 P02_PP | 0.227613 | 15.7673 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_BIE 30
1407458 | Nivell 03 P03_PP | 0.947613 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1407460 | Nivell 03 P03_PP | 17.6952 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1407464 | Nivell 03 P03_PP | 16.0476 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1407486 | Nivell 02 P02_PP | 0.947613 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407488 | Nivell 02 P02_PP | 17.6952 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407492 | Nivell 02 P02_PP | 16.0476 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1407589 | Nivell 04 P04_PP | 0.917613 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1407601 | Nivell 04 P04_PP | 17.6952 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1407609 | Nivell 04 P04_PP | 16.0176 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1407716 | Nivell 00 P00_PB | 7.09982 | 10.6865 | 11_CI_BIE 1
1407758 | Nivell 00 P00_PB | 1.08465 | 10.4765 | 11_CI_BIE 1
1407774 | Nivell 00 P00_PB | 2.93681 | 7.53 | 11_CI_BIE 1
1407817 | Nivell 00 P00_PB | 3.04761 | 10.4834 | 11_CI_BIE 1
1407825 | Nivell 00 P00_PB | 11.8142 | 10.4834 | 11_CI_BIE 1
1407836 | Nivell 00 P00_PB | 2.74059 | 10.4834 | 11_CI_BIE 1
1407846 | Nivell 00 P00_PB | 1.4596 | 10.4765 | 11_CI_BIE 1
1407872 | Nivell 00 P00_PB | 15.6268 | 10.6865 | 11_CI_BIE 1
1407891 | Nivell 00 P00_PB | 4.51635 | 5.95159 | 11_CI_BIE 1
1407973 | Nivell 00 P00_PB | 2.44757 | 10.7865 | 11_CI_BIE 1
1408124 | Nivell 00 P00_PB | 1.65745 | 10.8873 | 11_CI_BIE 32
1408132 | Nivell 00 P00_PB | 0.395225 | 10.4873 | 11_CI_BIE 32
1408183 | Nivell 00 P00_PB | 5.64761 | 4.83 | 11_CI_BIE 32
1408324 | Nivell -01 PS1_PK | 7.48429 | 5.85648 | 11_CI_BIE 1
1408340 | Nivell -01 PS1_PK | 4.84523 | 5.85648 | 11_CI_BIE 1
1408366 | Nivell -01 PS1_PK | 2.49681 | 3.35 | 11_CI_BIE 1
1408390 | Nivell -01 PS1_PK | 1.21063 | 5.65648 | 11_CI_BIE 1
1408402 | Nivell -01 PS1_PK | 16.4913 | 5.85648 | 11_CI_BIE 1
1408441 | Nivell -01 PS1_PK | 1.01761 | 5.25648 | 11_CI_BIE 1
1408502 | Nivell -01 PS1_PK | 0.644594 | 5.27648 | 11_CI_BIE 1
1408512 | Nivell -01 PS1_PK | 3.36523 | 5.47648 | 11_CI_BIE 1
1408522 | Nivell -01 PS1_PK | 6.78888 | 5.47648 | 11_CI_BIE 1
1408530 | Nivell -01 PS1_PK | 0.641263 | 5.47648 | 11_CI_BIE 1
1408564 | Nivell -01 PS1_PK | 0.537315 | 4.40648 | 11_CI_BIE 1
1408584 | Nivell -01 PS1_PK | 0.668875 | 4.40648 | 11_CI_BIE 1
1408648 | Nivell -01 PS1_PK | 3.42841 | 4.50159 | 11_CI_BIE 1
1408995 | Nivell -01 PS1_PK | 1.65824 | 5.47648 | 11_CI_BIE 1
1409003 | Nivell -01 PS1_PK | 0.965225 | 4.50159 | 11_CI_BIE 1
1410288 | Nivell -01 PS1_PK | 13.8676 | 4.40648 | 11_CI_BIE 1
1411053 | Nivell -01 PS1_PK | 4.24761 | 5.47648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411059 | Nivell -01 PS1_PK | 1.80156 | 5.47648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411071 | Nivell -01 PS1_PK | 6.45062 | 5.85648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411082 | Nivell -01 PS1_PK | 1.94887 | 5.85648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411092 | Nivell -01 PS1_PK | 1.46894 | 5.85648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411118 | Nivell -01 PS1_PK | 4.52523 | 5.95159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411604 | Nivell 00 P00_PB | 0.979579 | 10.4865 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411616 | Nivell 00 P00_PB | 1.59597 | 10.6865 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411626 | Nivell 00 P00_PB | 0.710846 | 10.6865 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1411634 | Nivell 00 P00_PB | 0.0376125 | 10.6865 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1421047 | Nivell 00 P00_PB | 0.617054 | 10.6881 | 11_CI_BIE 1
1421153 | Nivell 00 P00_PB | 1.97063 | 10.4765 | 11_CI_BIE 1
1421402 | Nivell 00 P00_PB | 11.0982 | 10.4765 | 11_CI_BIE 1
1421514 | Nivell 00 P00_PB | 0.106825 | 10.5716 | 11_CI_BIE 1
1421539 | Nivell 00 P00_PB | 0.106825 | 10.5716 | 11_CI_BIE 1
1421596 | Nivell 00 P00_PB | 0.105225 | 10.5716 | 11_CI_BIE 1
1421765 | Nivell 00 P00_PB | 1.32114 | 10.6865 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1421851 | Nivell 00 P00_PB | 0.105225 | 10.5716 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1421997 | Nivell 04 P04_PP | 3.72459 | 25.4165 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1422061 | Nivell 04 P04_PP | 7.29951 | 25.6681 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1422071 | Nivell 04 P04_PP | 0.146825 | 25.5116 | Model Group:11_CI_P4:1407536; 11_CI_RUIX 6 | Material: ARC_METALL_AN
1422166 | Nivell 03 P03_PP | 0.724594 | 21.6665 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1422213 | Nivell 03 P03_PP | 10.2995 | 21.9181 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1422221 | Nivell 03 P03_PP | 0.146825 | 21.7616 | Model Group:11_CI_Planta tipus inferiors:1407028; 11_CI_RUIX 4 | Material: ARC_METALL_AN
1422393 | Nivell 02 P02_PP | 0.724594 | 17.9165 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1422395 | Nivell 02 P02_PP | 10.2995 | 18.1681 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1422397 | Nivell 02 P02_PP | 0.146825 | 18.0116 | Model Group:11_CI_Planta tipus inferiors:1407301; 11_CI_RUIX 1 | Material: ARC_METALL_AN
1422485 | Nivell 06 P06_PP | 3.74459 | 32.9965 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1422533 | Nivell 06 P06_PP | 7.28586 | 33.1681 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1422568 | Nivell 06 P06_PP | 0.066825 | 33.0916 | Model Group:11_CI_Planta tipus:1406452; 11_CI_RUIX 3 | Material: ARC_METALL_AN
1422669 | Nivell 05 P05_PP | 3.74459 | 29.2465 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1422671 | Nivell 05 P05_PP | 7.28586 | 29.4181 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1422673 | Nivell 05 P05_PP | 0.066825 | 29.3416 | Model Group:11_CI_Planta tipus:1406628; 11_CI_RUIX 8 | Material: ARC_METALL_AN
1466519 | Nivell 00 P00_PB | 7.69523 | 10.4873 | 11_CI_BIE 32
1466675 | Nivell 00 P00_PB | 0.295225 | 10.5824 | 11_CI_BIE 32
1485813 | Nivell 00 P00_PB | 0.095225 | 10.5816 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1486056 | Nivell 00 P00_PB | 0.126153 | 10.4776 | 11_CI_BIE 1
1486197 | Nivell 00 P00_PB | 0.0983521 | 10.5785 | 11_CI_BIE 1
1486225 | Nivell 00 P00_PB | 2.21305 | 10.4795 | 11_CI_BIE 1
1486657 | Nivell 00 P00_PB | 0.138875 | 10.4833 | 11_CI_BIE 1
1486879 | Nivell 00 P00_PB | 0.430631 | 10.4834 | 11_CI_BIE 1
1486886 | Nivell 00 P00_PB | 1.63063 | 10.4765 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1487217 | Nivell 00 P00_PB | 0.0982813 | 10.5785 | 11_CI_BIE 1
1487250 | Nivell 00 P00_PB | 0.105225 | 10.5716 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1487450 | Nivell 00 P00_PB | 0.098875 | 10.5716 | 11_CI_BIE 1
1487453 | Nivell 00 P00_PB | 1.7306 | 10.6865 | 11_CI_BIE 1
1487467 | Nivell 00 P00_PB | 0.105225 | 10.5716 | 11_CI_BIE 1
1488750 | Nivell 00 P00_PB | 0.0593625 | 10.5042 | 03_FN_AFS 7
1488758 | Nivell 00 P00_PB | 1.27872 | 10.5042 | 03_FN_AFS 7
1488781 | Nivell 00 P00_PB | 1.98568 | 10.6981 | 03_FN_AFS 7
1488802 | Nivell 00 P00_PB | 7.50889 | 10.348 | 03_FN_AFS 7
1488810 | Nivell 00 P00_PB | 0.728725 | 10.348 | 03_FN_AFS 7
1488820 | Nivell 00 P00_PB | 2.04266 | 10.348 | 03_FN_AFS 7
1488878 | Nivell 00 P00_PB | 1.10936 | 10.5042 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1488883 | Nivell 00 P00_PB | 1.98472 | 10.6981 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1488889 | Nivell 00 P00_PB | 7.59676 | 10.348 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1488897 | Nivell 00 P00_PB | 0.728725 | 10.348 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1488905 | Nivell 00 P00_PB | 1.89266 | 10.348 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489872 | Nivell 00 P00_PB | 0.152675 | 10.5398 | 03_FN_AFS 7
1489883 | Nivell 00 P00_PB | 0.152675 | 10.5398 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489892 | Nivell 00 P00_PB | 0.208725 | 10.4838 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1489903 | Nivell 00 P00_PB | 0.208725 | 10.4838 | 03_FN_AFS 7
1491524 | Nivell 00 P00_PB | 2.72735 | 10.4481 | 03_FN_AFS 7
1491531 | Nivell 00 P00_PB | 2.57734 | 10.4481 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1491561 | Nivell 00 P00_PB | 0.0588662 | 10.3836 | 03_FN_AFS 7
1491597 | Nivell 00 P00_PB | 0.0588662 | 10.3836 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1495747 | Nivell 00 P00_PB | 4.95081 | 10.348 | 03_FN_AFS 7
1495753 | Nivell 00 P00_PB | 5.01295 | 10.348 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1495901 | Nivell 00 P00_PB | 0.902142 | 10.348 | 03_FN_AFS 7
1495960 | Nivell 00 P00_PB | 0.902142 | 10.348 | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 6
1497641 | Nivell -01 PS1_PK | 0.0436074 | 5.85648 | 11_CI_BIE 1
1497647 | Nivell -01 PS1_PK | 0.119511 | 5.85648 | 11_CI_BIE 1
1518525 | Nivell -01 PS1_PK | 3.11146 | 5.47648 | 11_CI_BIE 1
1518533 | Nivell -01 PS1_PK | 8.8704 | 5.47648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1521177 | Nivell -01 PS1_PK | 2.16679 | 5.85648 | 11_CI_BIE 1
1521184 | Nivell -01 PS1_PK | 1.03063 | 5.65648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1521280 | Nivell -01 PS1_PK | 0.095225 | 5.75159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1521317 | Nivell -01 PS1_PK | 0.095225 | 5.75159 | 11_CI_BIE 1
1521537 | Nivell -01 PS1_PK | 0.095225 | 5.75159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1521559 | Nivell -01 PS1_PK | 0.088875 | 5.75159 | 11_CI_BIE 1
1521562 | Nivell -01 PS1_PK | 4.7749 | 5.85648 | 11_CI_BIE 1
1521594 | Nivell -01 PS1_PK | 0.275225 | 5.57159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1521627 | Nivell -01 PS1_PK | 0.275225 | 5.57159 | 11_CI_BIE 1
1536094 | Nivell 00 P00_PB | 0.205225 | 10.5716 | 11_CI_BIE 1
1551095 | Nivell 01 P01_PP | 1.39522 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 1
1551106 | Nivell -01 PS1_PK | 9.26 | 4.89681 | 11_CI_BIE 1
1551211 | Nivell 01 P01_PP | 0.595299 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 1
1551223 | Nivell 01 P01_PP | 2.96761 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 1
1551284 | Nivell 01 P01_PP | 0.227613 | 12.0173 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 11
1551286 | Nivell 01 P01_PP | 0.167613 | 12.0173 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 11
1551290 | Nivell 01 P01_PP | 0.125913 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551291 | Nivell 01 P01_PP | 0.419563 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551293 | Nivell 01 P01_PP | 5.28936 | 14.4181 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551295 | Nivell 01 P01_PP | 2.74761 | 14.4181 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551297 | Nivell 01 P01_PP | 0.227613 | 12.0173 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 25
1551301 | Nivell 01 P01_PP | 0.227613 | 12.0173 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 27
1551303 | Nivell 01 P01_PP | 0.227613 | 12.0173 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_BIE 28
1551306 | Nivell 01 P01_PP | 0.947613 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551307 | Nivell 01 P01_PP | 17.6952 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551309 | Nivell 01 P01_PP | 16.0476 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551311 | Nivell 01 P01_PP | 0.724594 | 14.1665 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551312 | Nivell 01 P01_PP | 10.2995 | 14.4181 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1551313 | Nivell 01 P01_PP | 0.146825 | 14.2616 | Model Group:11_CI_Planta tipus P1:1407104; 11_CI_RUIX 2 | Material: ARC_METALL_AN
1554291 | Nivell -01 PS1_PK | 0.914658 | 5.27648 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1554394 | Nivell -01 PS1_PK | 0.095225 | 5.37159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1554403 | Nivell -01 PS1_PK | 0.095225 | 5.37159 | 11_CI_BIE 1
1554426 | Nivell -01 PS1_PK | 0.095225 | 5.37159 | 11_CI_RUIX 5 | Material: ARC_METALL_AN
1554461 | Nivell -01 PS1_PK | 0.095225 | 5.37159 | 11_CI_BIE 1
1561085 | Nivell -01 PS1_PK | 0.245225 | 4.50159 | 11_CI_BIE 1
1561100 | Nivell -01 PS1_PK | 8.73931 | 4.75596 | 11_CI_BIE 1
1575169 | Nivell -01 PS1_PK | 0.108875 | 5.35159 | 11_CI_BIE 1
1575172 | Nivell -01 PS1_PK | 5.64485 | 5.47648 | 11_CI_BIE 1
1576943 | Nivell -01 PS1_PK | 4.72416 | 4.40648 | 11_CI_BIE 1
1576985 | Nivell -01 PS1_PK | 0.136601 | 4.40648 | 11_CI_BIE 1
1576995 | Nivell -01 PS1_PK | 4.09404 | 4.40648 | 11_CI_BIE 1

# IfcFlowSegment: Pipe Types:PPR_CLI_Aquatherm Blue Pipe (381)
Type - Pset_ManufacturerTypeInformation - Manufacturer: AQUATHERM
Classification: 50.30.30.20 Línies hidràuliques (Uniformat)
Pset_DistributionFlowElementCommon - Reference: PPR_CLI_Aquatherm Blue Pipe; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:PPR_CLI_Aquatherm Blue Pipe:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) | InvertElevation (m) | Group
1385865 | Nivell 07 P07_PP | 0.294402 | 36.5146 | 05_CA_AF_RET 3
1385880 | Nivell 07 P07_PP | 5.23333 | 36.5146 | 05_CA_AF_RET 3
1385896 | Nivell 07 P07_PP | 0.493663 | 36.8146 | 05_CA_AF_RET 2
1385904 | Nivell 07 P07_PP | 3.56666 | 36.8146 | 05_CA_AF_RET 2
1385992 | Nivell 07 P07_PP | 0.494406 | 36.5146 | 05_CA_AF_IMP 2
1385999 | Nivell 07 P07_PP | 0.700761 | 36.5237 | 05_CA_AC_RET 1
1386006 | Nivell 07 P07_PP | 0.900765 | 36.5237 | 05_CA_AC_IMP 1
1386019 | Nivell 07 P07_PP | 5.23333 | 36.5146 | 05_CA_AF_IMP 2
1386026 | Nivell 07 P07_PP | 5.24603 | 36.5237 | 05_CA_AC_RET 1
1386033 | Nivell 07 P07_PP | 5.24603 | 36.5237 | 05_CA_AC_IMP 1
1386046 | Nivell 07 P07_PP | 4.42366 | 36.5146 | 05_CA_AF_IMP 2
1386053 | Nivell 07 P07_PP | 4.33201 | 36.5237 | 05_CA_AC_RET 1
1386060 | Nivell 07 P07_PP | 4.13201 | 36.5237 | 05_CA_AC_IMP 1
1386073 | Nivell 07 P07_PP | 3.76666 | 36.8146 | 05_CA_AF_IMP 3
1386080 | Nivell 07 P07_PP | 3.97301 | 36.8237 | 05_CA_AC_RET 2
1386087 | Nivell 07 P07_PP | 4.17301 | 36.8237 | 05_CA_AC_IMP 4
1386246 | Nivell 07 P07_PP | 4.62366 | 36.5146 | 05_CA_AF_RET 3
1386296 | Nivell 07 P07_PP | 0.693663 | 36.8146 | 05_CA_AF_IMP 3
1386330 | Nivell 07 P07_PP | 0.802013 | 36.8237 | 05_CA_AC_RET 2
1386340 | Nivell 07 P07_PP | 1.00201 | 36.8237 | 05_CA_AC_IMP 4
1386486 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AF_RET 1
1386547 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AF_IMP 1
1386561 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AC_RET 3
1386577 | Nivell 07 P07_PP | 30.59 | 5.91 | 05_CA_AC_IMP 2
1386931 | Nivell 07 P07_PP | 0.125 | 36.6782 | 05_CA_AF_RET 4
