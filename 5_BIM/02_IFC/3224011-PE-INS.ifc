Properties of the parts of a building model (IFC2X3), part 6 of 11

# IfcDistributionPort (7229)
Name | FlowDirection | Group
Port_1554571_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1569200_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1554571_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572362_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1554573_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1569211_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1554573_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572407_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1556988_0 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556992_2 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556988_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556998_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556990_0 | SOURCEANDSINK | 04_SN_APLU 23
Port_1557267_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556990_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556992_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556994_0 | SOURCEANDSINK | 04_SN_APLU 23
Port_1557000_2 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556994_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556996_0 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556998_2 | SOURCEANDSINK | 04_SN_APLU 23
Port_1556996_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1557000_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1557267_2 | SOURCEANDSINK | 04_SN_APLU 23
Port_1581133_0 | SOURCEANDSINK | 04_SN_APLU 23
Port_1557807_0 | SOURCEANDSINK | VEN_EXT 6
Port_1557929_1 | SOURCEANDSINK | VEN_EXT 6
Port_1557807_1 | SOURCEANDSINK | VEN_EXT 6
Port_1557904_1 | SOURCEANDSINK | VEN_EXT 6
Port_1557902_0 | SOURCEANDSINK | VEN_EXT 6
Port_1557904_2 | SOURCEANDSINK | VEN_EXT 6
Port_1557902_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576020_1 | SOURCEANDSINK | VEN_EXT 6
Port_1558109_0 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558117_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558109_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558123_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558111_0 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558117_2 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558111_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558141_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558113_0 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558121_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558113_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558115_0 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558121_2 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558115_1 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558123_2 | SOURCEANDSINK | 04_SN_AFEC 16
Port_1558125_0 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558129_2 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558125_1 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558135_1 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558127_0 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558407_1 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558127_1 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558129_1 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558131_0 | SOURCEANDSINK | 04_SN_APLU 18
Port_1558137_2 | SOURCEANDSINK | 04_SN_APLU 18
Port_1558131_1 | SOURCEANDSINK | 04_SN_APLU 18
Port_1558133_0 | SOURCEANDSINK
Port_1558133_1 | SOURCEANDSINK
Port_1558135_2 | SOURCEANDSINK | 04_SN_APLU 14
Port_1558137_1 | SOURCEANDSINK | 04_SN_APLU 18
Port_1558527_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558543_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558527_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559340_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558538_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558540_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558538_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558543_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558547_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559615_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558547_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558997_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559615_3 | SOURCEANDSINK | 04_SN_APLU 20
Port_1558997_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581909_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559340_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559616_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559615_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1559616_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1560159_1 | SOURCEANDSINK | 04_SN_AFEC 7
Port_1561085_0 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561087_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561085_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561089_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561089_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561100_0 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561100_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1561332_0 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1567982_1 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1561332_1 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1561338_1 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1561345_0 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1567995_1 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1561345_1 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1561349_1 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1561356_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1561358_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1561356_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1568008_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1561365_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1568021_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1561365_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1561372_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1561543_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1561639_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1561543_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1561644_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1561572_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567396_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561572_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561655_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561583_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561650_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561583_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561655_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1561612_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567444_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561612_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561666_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561623_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561661_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561623_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561666_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561644_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567319_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1561819_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1561821_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1561819_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1561823_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1561828_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1561830_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1561828_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1561832_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1561841_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561843_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561841_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561845_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561843_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1563065_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1561854_0 | SOURCEANDSINK | 03_FN_AFS 1
Port_1561856_2 | SOURCEANDSINK | 03_FN_AFS 1
Port_1561854_1 | SOURCEANDSINK | 03_FN_AFS 1
Port_1561858_1 | SOURCEANDSINK | 03_FN_AFS 1
Port_1563065_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564113_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1563077_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564017_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1563077_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564019_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1563670_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563847_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563670_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563851_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563789_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563839_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563837_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563839_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563837_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563851_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1563939_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564121_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1563939_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564125_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564007_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564121_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564007_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564019_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564111_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564113_3 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564111_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564125_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564113_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564114_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1564114_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567188_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567486_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567206_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567533_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567206_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567535_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567237_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567578_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567237_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1572896_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567319_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567335_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567329_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567335_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567329_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567476_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567388_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567396_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567388_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567522_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567436_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567444_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567436_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567569_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567474_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567476_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567474_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567486_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1567520_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567522_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567520_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567535_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1567567_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567569_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567567_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1572896_3 | SOURCEANDSINK | 03_FN_AFS 4
Port_1567974_0 | SOURCEANDSINK | 05_CA_AF_IMP 12
Port_1567976_2 | SOURCEANDSINK | 05_CA_AF_IMP 12
Port_1567974_1 | SOURCEANDSINK | 05_CA_AF_IMP 12
Port_1567982_2 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1595587_0 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1567987_0 | SOURCEANDSINK | 05_CA_AF_RET 9
Port_1567989_2 | SOURCEANDSINK | 05_CA_AF_RET 9
Port_1567987_1 | SOURCEANDSINK | 05_CA_AF_RET 9
Port_1567995_2 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1595615_0 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1568000_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1568002_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1568000_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1571628_3 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1568013_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1568015_2 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1568013_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1571637_3 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1568185_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568772_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568185_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568776_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568506_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568521_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568506_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568508_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568530_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568508_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568517_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568776_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568517_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568521_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 1
Port_1568528_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568530_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568528_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568766_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568762_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569294_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1568766_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569284_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569198_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1569200_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1569198_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1569202_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1569207_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1569209_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1569207_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1569211_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1569284_0 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569293_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569293_2 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1569294_1 | SOURCEANDSINK | 17_XRX_1ria_REG 3
Port_1571491_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1572896_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1571491_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575589_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1571499_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575604_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1571499_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575589_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1571628_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1575893_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1571637_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1575866_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1572341_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572358_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572341_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572362_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572352_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572947_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572352_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572358_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572355_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572945_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572355_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572947_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1572388_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572403_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572388_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572407_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572397_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572941_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572397_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572403_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572400_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575627_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572400_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572941_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572665_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576560_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572665_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576564_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1572945_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575371_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575169_0 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575171_3 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575169_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575175_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575171_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575172_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1575371_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575533_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575388_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575623_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575388_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575627_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575416_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577487_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575416_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576510_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575523_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575533_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575523_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576605_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575535_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576605_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575535_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576607_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1575573_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575623_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575573_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576560_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1575578_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576503_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575578_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575604_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1575866_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577748_2 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1575893_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577709_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1576069_0 | SOURCEANDSINK | VEN_EXT 6
Port_1576077_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576069_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576244_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576216_0 | SOURCEANDSINK | VEN_EXT 6
Port_1576241_2 | SOURCEANDSINK | VEN_EXT 6
Port_1576216_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576244_2 | SOURCEANDSINK | VEN_EXT 6
Port_1576239_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576241_1 | SOURCEANDSINK | VEN_EXT 6
Port_1576412_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576441_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576412_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576414_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576445_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576414_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576416_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576449_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576416_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576487_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576489_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576487_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576510_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576503_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577488_0 | SOURCEANDSINK | 03_FN_AFS 4
Port_1576543_0 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576545_2 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576543_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576564_1 | SOURCEANDSINK | 03_FN_Aigua Grisa (AGRIS) (Fluxors) - Impulsió 2
Port_1576595_0 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576597_2 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576595_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576607_1 | SOURCEANDSINK | 17_XRX_1ria_REG 1
Port_1576943_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576993_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576985_0 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576993_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576985_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1577044_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576995_0 | SOURCEANDSINK | 11_CI_BIE 1
Port_1577044_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1576995_1 | SOURCEANDSINK | 11_CI_BIE 1
Port_1577046_2 | SOURCEANDSINK | 11_CI_BIE 1
Port_1577125_0 | SOURCEANDSINK | 05_CA_AF_RET 12
Port_1578039_2 | SOURCEANDSINK | 05_CA_AF_RET 12
Port_1577125_1 | SOURCEANDSINK | 05_CA_AF_RET 12
Port_1577127_0 | SOURCEANDSINK | 05_CA_AF_IMP 15
Port_1578032_2 | SOURCEANDSINK | 05_CA_AF_IMP 15
Port_1577127_1 | SOURCEANDSINK | 05_CA_AF_IMP 15
Port_1577129_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1578017_2 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577129_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1578020_2 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577131_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1578008_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577131_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1578011_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577487_2 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577488_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577487_3 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577492_1 | SOURCEANDSINK | 03_FN_AFS 4
Port_1577694_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577709_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577694_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577868_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577738_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577748_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577738_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577879_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577866_0 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577868_2 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577866_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1578011_1 | SOURCEANDSINK | 05_CA_AC_IMP 12
Port_1577877_0 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577879_2 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1577877_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1578020_1 | SOURCEANDSINK | 05_CA_AC_RET 12
Port_1579727_0 | SOURCEANDSINK | VEN_EXT 6
Port_1579740_2 | SOURCEANDSINK | VEN_EXT 6
Port_1579727_1 | SOURCEANDSINK | VEN_EXT 6
Port_1579771_2 | SOURCEANDSINK | VEN_EXT 6
Port_1579743_0 | SOURCEANDSINK | VEN_EXT 6
Port_1579767_2 | SOURCEANDSINK | VEN_EXT 6
Port_1579743_1 | SOURCEANDSINK | VEN_EXT 6
Port_1579771_1 | SOURCEANDSINK | VEN_EXT 6
Port_1579762_0 | SOURCEANDSINK | VEN_EXT 6
Port_1579764_2 | SOURCEANDSINK | VEN_EXT 6
Port_1579762_1 | SOURCEANDSINK | VEN_EXT 6
Port_1579767_1 | SOURCEANDSINK | VEN_EXT 6
Port_1580776_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580854_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580776_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580817_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580789_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580789_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580815_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580817_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580815_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580966_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580837_0 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580859_2 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580837_1 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580854_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580855_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580854_3 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1594151_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580855_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589230_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1580859_1 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580864_1 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580864_2 | SOURCEANDSINK | 04_SN_AFEC 8
Port_1580966_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1581086_0 | SOURCEANDSINK | 04_SN_APLU 11
Port_1581238_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1581086_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1581133_1 | SOURCEANDSINK | 04_SN_APLU 23
Port_1581159_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581911_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581159_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581423_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584660_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1581763_0 | SOURCEANDSINK | 04_SN_AFEC 28
Port_1581788_2 | SOURCEANDSINK | 04_SN_AFEC 28
Port_1581763_1 | SOURCEANDSINK | 04_SN_AFEC 28
Port_1581795_2 | SOURCEANDSINK | 04_SN_AFEC 28
Port_1581788_1 | SOURCEANDSINK | 04_SN_AFEC 28
Port_1581907_0 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581909_2 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581907_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1581911_1 | SOURCEANDSINK | 04_SN_APLU 20
Port_1584634_0 | SOURCEANDSINK | 04_SN_APLU 11
Port_1594980_3 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584634_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584660_2 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584654_0 | SOURCEANDSINK | 04_SN_APLU 11
Port_1594980_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584654_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1586353_2 | SOURCEANDSINK | 04_SN_APLU 11
Port_1584896_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586069_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585047_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585599_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585047_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585714_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585349_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1595827_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585349_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585595_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585359_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585595_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585359_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585599_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585699_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586107_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585699_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586065_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585710_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585712_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585710_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585716_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585712_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585714_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585716_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586108_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585913_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586103_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1585913_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586115_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586019_0 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586065_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586019_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586069_2 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586107_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586108_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586107_3 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586115_1 | SOURCEANDSINK | 04_SN_AFEC 18
Port_1586341_0 | SOURCEANDSINK | 04_SN_APLU 11
Port_1586343_2 | SOURCEANDSINK | 04_SN_APLU 11
Port_1586341_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1586353_1 | SOURCEANDSINK | 04_SN_APLU 11
Port_1586500_0 | SOURCEANDSINK | CLI_RET 8
Port_1588373_1 | SOURCEANDSINK | CLI_RET 8
Port_1586500_1 | SOURCEANDSINK | CLI_RET 8
Port_1587320_0 | SOURCEANDSINK | CLI_RET 7
Port_1587321_2 | SOURCEANDSINK | CLI_RET 7
Port_1587320_1 | SOURCEANDSINK | CLI_RET 7
Port_1587321_1 | SOURCEANDSINK | CLI_RET 7
Port_1587322_0 | SOURCEANDSINK | CLI_RET 7
Port_1587322_1 | SOURCEANDSINK | CLI_RET 7
Port_1587324_1 | SOURCEANDSINK | CLI_RET 7
Port_1587323_0 | SOURCEANDSINK | CLI_RET 7
Port_1587324_2 | SOURCEANDSINK | CLI_RET 7
Port_1587323_1 | SOURCEANDSINK | CLI_RET 7
Port_1587690_0 | SOURCEANDSINK | CLI_IMP 11
Port_1588232_2 | SOURCEANDSINK | CLI_IMP 11
Port_1587690_1 | SOURCEANDSINK | CLI_IMP 11
Port_1587997_0 | SOURCEANDSINK | CLI_IMP 11
Port_1588232_1 | SOURCEANDSINK | CLI_IMP 11
Port_1587997_1 | SOURCEANDSINK | CLI_IMP 11
Port_1588233_2 | SOURCEANDSINK | CLI_IMP 11
Port_1588225_0 | SOURCEANDSINK | CLI_IMP 11
Port_1588225_1 | SOURCEANDSINK | CLI_IMP 11
Port_1588227_1 | SOURCEANDSINK | CLI_IMP 11
Port_1588226_0 | SOURCEANDSINK | CLI_IMP 11
Port_1588227_2 | SOURCEANDSINK | CLI_IMP 11
Port_1588226_1 | SOURCEANDSINK | CLI_IMP 11
Port_1588233_1 | SOURCEANDSINK | CLI_IMP 11
Port_1588366_0 | SOURCEANDSINK | CLI_RET 8
Port_1588373_2 | SOURCEANDSINK | CLI_RET 8
Port_1588366_1 | SOURCEANDSINK | CLI_RET 8
Port_1588383_1 | SOURCEANDSINK | CLI_RET 8
Port_1588378_0 | SOURCEANDSINK | CLI_RET 8
Port_1588383_2 | SOURCEANDSINK | CLI_RET 8
Port_1588378_1 | SOURCEANDSINK | CLI_RET 8
Port_1588611_0 | SOURCEANDSINK | CLI_IMP 7
Port_1588613_1 | SOURCEANDSINK | CLI_IMP 7
Port_1588611_1 | SOURCEANDSINK | CLI_IMP 7
Port_1588612_0 | SOURCEANDSINK | CLI_IMP 7
Port_1588613_2 | SOURCEANDSINK | CLI_IMP 7
Port_1588612_1 | SOURCEANDSINK | CLI_IMP 7
Port_1588615_1 | SOURCEANDSINK | CLI_IMP 7
Port_1588614_0 | SOURCEANDSINK | CLI_IMP 7
Port_1588615_2 | SOURCEANDSINK | CLI_IMP 7
Port_1588614_1 | SOURCEANDSINK | CLI_IMP 7
Port_1588628_0 | SOURCEANDSINK | CLI_RET 12
Port_1588630_1 | SOURCEANDSINK | CLI_RET 12
Port_1588628_1 | SOURCEANDSINK | CLI_RET 12
Port_1588629_0 | SOURCEANDSINK | CLI_RET 12
Port_1588630_2 | SOURCEANDSINK | CLI_RET 12
Port_1588629_1 | SOURCEANDSINK | CLI_RET 12
Port_1588632_1 | SOURCEANDSINK | CLI_RET 12
Port_1588631_0 | SOURCEANDSINK | CLI_RET 12
Port_1588632_2 | SOURCEANDSINK | CLI_RET 12
Port_1588631_1 | SOURCEANDSINK | CLI_RET 12
Port_1589224_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589230_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589224_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589234_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589225_0 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589225_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589234_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589239_1 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1589243_2 | SOURCEANDSINK | 04_SN_AFEC 20
Port_1592912_0 | SOURCEANDSINK | VEN_EXT 4
Port_1592912_1 | SOURCEANDSINK | VEN_EXT 4
Port_1592927_1 | SOURCEANDSINK | VEN_EXT 4
Port_1592920_0 | SOURCEANDSINK | VEN_EXT 4
Port_1592927_2 | SOURCEANDSINK | VEN_EXT 4
Port_1592920_1 | SOURCEANDSINK | VEN_EXT 4
Port_1592995_0 | SOURCEANDSINK | VEN_EXT 24
Port_1592995_1 | SOURCEANDSINK | VEN_EXT 24
Port_1592997_1 | SOURCEANDSINK | VEN_EXT 24
Port_1592996_0 | SOURCEANDSINK | VEN_EXT 24
Port_1592997_2 | SOURCEANDSINK | VEN_EXT 24
Port_1592996_1 | SOURCEANDSINK | VEN_EXT 24
Port_1593011_0 | SOURCEANDSINK | VEN_EXT 1
Port_1595983_2 | SOURCEANDSINK | VEN_EXT 1
Port_1593011_1 | SOURCEANDSINK | VEN_EXT 1
Port_1593082_0 | SOURCEANDSINK | VEN_EXT 35
Port_1593082_1 | SOURCEANDSINK | VEN_EXT 35
Port_1593104_1 | SOURCEANDSINK | VEN_EXT 35
Port_1593101_0 | SOURCEANDSINK | VEN_EXT 35
Port_1593104_2 | SOURCEANDSINK | VEN_EXT 35
Port_1593101_1 | SOURCEANDSINK | VEN_EXT 35
Port_1593765_2 | SOURCEANDSINK | 04_SN_APLU 17
Port_1594265_1 | SOURCEANDSINK | 04_SN_APLU 17
Port_1593802_0 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593802_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593947_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593856_0 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593947_2 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593856_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593951_2 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593928_0 | SOURCEANDSINK | 04_SN_APLU 9
Port_1594387_2 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593928_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593951_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593930_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593931_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593930_2 | SOURCEANDSINK | 04_SN_APLU 9
Port_1594385_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1593930_3 | SOURCEANDSINK | 04_SN_APLU 9
Port_1594387_1 | SOURCEANDSINK | 04_SN_APLU 9
Port_1594151_2 | SOURCEANDSINK | 04_SN_AFEC 20
InPort_1594649_0 | SINK | 04_SN_APLU 11
OutPort_1594665_2 | SOURCE | 04_SN_APLU 11
InPort_1594948_1 | SINK | 04_SN_APLU 11
OutPort_1594649_1 | SOURCE | 04_SN_APLU 11
InPort_1594669_0 | SINK | 04_SN_APLU 11
OutPort_1594950_2 | SOURCE | 04_SN_APLU 11
InPort_1595057_1 | SINK | 04_SN_APLU 11
OutPort_1594669_1 | SOURCE | 04_SN_APLU 11
InPort_1594946_0 | SINK | 04_SN_APLU 11
OutPort_1594948_2 | SOURCE | 04_SN_APLU 11
InPort_1594950_1 | SINK | 04_SN_APLU 11
OutPort_1594946_1 | SOURCE | 04_SN_APLU 11
InPort_1594960_0 | SINK | 04_SN_APLU 11
OutPort_1595057_2 | SOURCE | 04_SN_APLU 11
InPort_1595059_1 | SINK | 04_SN_APLU 11
OutPort_1594960_1 | SOURCE | 04_SN_APLU 11
InPort_1594980_2 | SINK | 04_SN_APLU 11
OutPort_1595059_2 | SOURCE | 04_SN_APLU 11
Port_1595587_1 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1595644_2 | SOURCEANDSINK | 05_CA_AF_IMP 9
Port_1595615_1 | SOURCEANDSINK | 05_CA_AF_RET 15
Port_1595642_2 | SOURCEANDSINK | 05_CA_AF_RET 15
InPort_1595825_0 | SINK | 04_SN_ABOM 1
OutPort_1595827_3 | SOURCE | 04_SN_ABOM 1
InPort_1595843_1 | SINK | 04_SN_ABOM 1
OutPort_1595825_1 | SOURCE | 04_SN_ABOM 1

# IfcFlowFitting: Codo 90º Soldadura a Tope SDR 11 BluePipe:Estándar (34)
Type - Material: Fuisiolen PP-R BLUE
Type - Pset_ManufacturerTypeInformation - Manufacturer: AQUATHERM
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (Codo 90º Soldadura a Tope SDR 11 BluePipe:Estándar:...) | In | Group
1386949 | Nivell 07 P07_PP | 05_CA_AF_RET 4
1386961 | Nivell 07 P07_PP | 05_CA_AF_IMP 4
1387678 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 7
1387684 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 7
1390037 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 11
1390043 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 11
1390180 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 16
1390186 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 16
1390323 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 21
1390329 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 21
1390466 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 26
1390472 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 26
1390609 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 31
1390615 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 31
1402565 | Nivell -01 PS1_PK | 05_CA_AF_RET 9
1402567 | Nivell -01 PS1_PK | 05_CA_AF_RET 9
1402576 | Nivell -01 PS1_PK | 05_CA_AF_IMP 12
1402578 | Nivell -01 PS1_PK | 05_CA_AF_IMP 12
1516010 | Nivell -01 PS1_PK | 05_CA_AF_IMP 12
1516012 | Nivell -01 PS1_PK | 05_CA_AF_RET 9
1528727 | Nivell -01 PS1_PK | 05_CA_AF_RET 15
1528729 | Nivell -01 PS1_PK | 05_CA_AF_RET 15
1528733 | Nivell -01 PS1_PK | 05_CA_AF_IMP 9
1528735 | Nivell -01 PS1_PK | 05_CA_AF_IMP 9
1561338 | Nivell -01 PS1_PK | 05_CA_AF_IMP 9
1561342 | Nivell -01 PS1_PK | 05_CA_AF_IMP 9
1561349 | Nivell -01 PS1_PK | 05_CA_AF_RET 15
1561353 | Nivell -01 PS1_PK | 05_CA_AF_RET 15
1567976 | Nivell -01 PS1_PK | 05_CA_AF_IMP 12
1567982 | Nivell -01 PS1_PK | 05_CA_AF_IMP 9
1567989 | Nivell -01 PS1_PK | 05_CA_AF_RET 9
1567995 | Nivell -01 PS1_PK | 05_CA_AF_RET 15
1578032 | Nivell -01 PS1_PK | 05_CA_AF_IMP 15
1578039 | Nivell -01 PS1_PK | 05_CA_AF_RET 12

# IfcFlowFitting: M_Codo - Genérico:Estándar (873)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Estándar; sets with these values: 2
Name (M_Codo - Genérico:Estándar:...) | In | Group
1339222 | Nivell 08 P08_PC | 04_SN_APLU 2
1339239 | Nivell 08 P08_PC | 04_SN_APLU 2
1339253 | Nivell 08 P08_PC | 04_SN_APLU 2
1339274 | Nivell 08 P08_PC | 04_SN_APLU 3
1346752 | Nivell 07 P07_PP | 04_SN_APLU 11
1346762 | Nivell 07 P07_PP | 04_SN_APLU 11
1347194 | Nivell 07 P07_PP | 04_SN_APLU 11
1347441 | Nivell 08 P08_PC | 04_SN_APLU 3
1347454 | Nivell 08 P08_PC | 04_SN_APLU 3
1347465 | Nivell 07 P07_PP | 04_SN_APLU 8
1347469 | Nivell 07 P07_PP | 04_SN_APLU 8
1347475 | Nivell 07 P07_PP | 04_SN_APLU 3
1347479 | Nivell 07 P07_PP | 04_SN_APLU 8
1347667 | Nivell 07 P07_PP | 04_SN_APLU 10
1348415 | Nivell 07 P07_PP | 04_SN_APLU 10
1348694 | Nivell 06 P06_PP | 04_SN_APLU 2
1348721 | Nivell 08 P08_PC | 04_SN_APLU 2
1348725 | Nivell 06 P06_PP | 04_SN_APLU 2
1348842 | Nivell 07 P07_PP | 04_SN_APLU 10
1348946 | Nivell 07 P07_PP | 04_SN_APLU 2
1349336 | Nivell 06 P06_PP | 04_SN_APLU 3
1349348 | Nivell 06 P06_PP | 04_SN_APLU 3
1350086 | Nivell 06 P06_PP | 04_SN_APLU 3
1350306 | Nivell 05 P05_PP | 04_SN_APLU 5
1350322 | Nivell 05 P05_PP | 04_SN_APLU 5
1350333 | Nivell 05 P05_PP | 04_SN_APLU 5
1350619 | Nivell 07 P07_PP | 04_SN_APLU 1
1350623 | Nivell 06 P06_PP | 04_SN_APLU 1
1351368 | Nivell 07 P07_PP | 04_SN_APLU 3
1351487 | Nivell 08 P08_PC | 04_SN_APLU 3
1351491 | Nivell 07 P07_PP | 04_SN_APLU 3
1352330 | Nivell 08 P08_PC | 04_SN_APLU 4
1352341 | Nivell 08 P08_PC | 04_SN_APLU 4
1352347 | Nivell 07 P07_PP | 04_SN_APLU 4
1352383 | Nivell 07 P07_PP | 04_SN_APLU 1
1352387 | Nivell 08 P08_PC | 04_SN_APLU 1
1352572 | Nivell 04 P04_PP | 04_SN_APLU 6
1352603 | Nivell 04 P04_PP | 04_SN_APLU 6
1352705 | Nivell 03 P03_PP | 04_SN_APLU 7
1352715 | Nivell 03 P03_PP | 04_SN_APLU 7
1352888 | Nivell 04 P04_PP | 04_SN_APLU 6
1353039 | Nivell 04 P04_PP | 04_SN_APLU 6
1353095 | Nivell 04 P04_PP | 04_SN_APLU 13
1353108 | Nivell 03 P03_PP | 04_SN_APLU 15
1353112 | Nivell 03 P03_PP | 04_SN_APLU 15
1353123 | Nivell 04 P04_PP | 04_SN_APLU 13
1353131 | Nivell 04 P04_PP | 04_SN_APLU 13
1363867 | Nivell 06 P06_PP | 04_SN_AFEC 25
1363877 | Nivell 06 P06_PP | 04_SN_AFEC 25
1363986 | Nivell 06 P06_PP | 04_SN_AFEC 25
1364307 | Nivell 06 P06_PP | 04_SN_AFEC 25
1366469 | Nivell 06 P06_PP | 04_SN_AFEC 25
1366673 | Nivell 06 P06_PP | 04_SN_AFEC 25
1366679 | Nivell 07 P07_PP | 04_SN_AFEC 25
1366683 | Nivell 06 P06_PP | 04_SN_AFEC 25
1367573 | Nivell 06 P06_PP | 04_SN_AFEC 1
1367767 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 2
1367794 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 2
1368428 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 1
1368535 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 1
1368692 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 3
1368696 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 3
1368702 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368815 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368995 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1368999 | Nivell 06 P06_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AGRIS 10
1369110 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369150 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369170 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369306 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369351 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369356 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369422 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 4
1369543 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369549 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369555 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369561 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369563 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369565 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1369569 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1370081; 04_SN_AFEC 5
1370432 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 15
1370436 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 15
1370442 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 12
1370446 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 12
1370468 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 17
1370472 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 17
1370478 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370508 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370524 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370526 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AGRIS 14
1370528 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370534 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370540 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370546 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370548 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370550 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370554 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 19
1370558 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370564 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370570 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370576 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370578 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370580 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370584 | Nivell 01 P01_PP | Model Group:04_SN_Planta tipus inferiors:1371756; 04_SN_AFEC 21
1370782 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 31
1370786 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 31
1370792 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 24
1370796 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 24
1370818 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 33
1370822 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 33
1370828 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370858 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370874 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370876 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AGRIS 16
1370878 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370884 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370890 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370896 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370898 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370900 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370904 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 35
1370908 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370914 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370920 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370926 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370928 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370930 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370934 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus:1370936; 04_SN_AFEC 37
1370957 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 39
1370961 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 39
1370967 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 30
1370971 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 30
1370993 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 41
1370997 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 41
1371003 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371033 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371049 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371051 | Nivell 05 P05_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AGRIS 17
1371053 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371059 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371065 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371071 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371073 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371075 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371079 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 43
1371083 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371089 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371095 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371101 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371103 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371105 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1371109 | Nivell 04 P04_PP | Model Group:04_SN_Planta tipus:1371111; 04_SN_AFEC 45
1372917 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 27
1372921 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 27
1372927 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 21
1372931 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 21
1372953 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 29
1372957 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 29
1372963 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1372993 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1373009 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1373011 | Nivell 03 P03_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AGRIS 2
1373013 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373019 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373025 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373031 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373033 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373035 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373039 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 32
1373043 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373049 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373055 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373061 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373063 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373065 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1373069 | Nivell 02 P02_PP | Model Group:04_SN_Planta tipus inferiors:1372736; 04_SN_AFEC 36
1375085 | Nivell 00 P00_PB | 04_SN_AGRIS 7
1375151 | Nivell 00 P00_PB | 04_SN_AFEC 10
1382953 | Nivell -03 PS2_PK | 04_SN_APLU 24
1383038 | Nivell -03 PS2_PK | 04_SN_APLU 24
1383048 | Nivell -03 PS2_PK | 04_SN_APLU 24
1383058 | Nivell -03 PS2_PK | 04_SN_APLU 24
1383823 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1383897 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1383900 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1383912 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1383921 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1383989 | Nivell -03 PS2_PK | 04_SN_ABOM 1
1384777 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1384889 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1384893 | Nivell -01 PS1_PK | 04_SN_AFEC 18
1385294 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1385320 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1385764 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1385768 | Nivell -03 PS2_PK | 04_SN_AFEC 13
1385902 | Nivell 07 P07_PP | 05_CA_AF_RET 3
1385951 | Nivell 07 P07_PP | 05_CA_AF_RET 3
1386109 | Nivell 07 P07_PP | 05_CA_AC_IMP 1
1386115 | Nivell 07 P07_PP | 05_CA_AC_RET 1
1386121 | Nivell 07 P07_PP | 05_CA_AF_IMP 2
1386522 | Nivell 07 P07_PP | 05_CA_AF_RET 2
1386605 | Nivell 07 P07_PP | 05_CA_AC_IMP 1
1386622 | Nivell 07 P07_PP | 05_CA_AC_IMP 4
1386657 | Nivell 07 P07_PP | 05_CA_AC_RET 2
1386678 | Nivell 07 P07_PP | 05_CA_AC_RET 1
1386699 | Nivell 07 P07_PP | 05_CA_AF_IMP 2
1386716 | Nivell 07 P07_PP | 05_CA_AF_IMP 3
1386957 | Nivell 07 P07_PP | 05_CA_AC_IMP 3
1386959 | Nivell 07 P07_PP | 05_CA_AC_RET 4
1387643 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1387647 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1387653 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1387657 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1387680 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 7
1387682 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 7
1389392 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1389411 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389428 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389447 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389503 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389505 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_RET 5
1389543 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389545 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AF_IMP 5
1389583 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389585 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_RET 5
1389623 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1389625 | Nivell 06 P06_PP | Model Group:05_CA_Pipes Planta tipus:1388135; 05_CA_AC_IMP 5
1390013 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390015 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390017 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390019 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390039 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 11
1390041 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 11
1390046 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390048 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390050 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390052 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390060 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390062 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_RET 8
1390070 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390072 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AF_IMP 8
1390080 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390082 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_RET 8
1390090 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390092 | Nivell 01 P01_PP | Model Group:05_CA_Pipes Planta tipus:1390045; 05_CA_AC_IMP 8
1390156 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390158 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390160 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390162 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390182 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 16
1390184 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 17
1390189 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390191 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390193 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390195 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390203 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390205 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_RET 13
1390213 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390215 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AF_IMP 13
1390223 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390225 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_RET 14
1390233 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390235 | Nivell 02 P02_PP | Model Group:05_CA_Pipes Planta tipus:1390188; 05_CA_AC_IMP 13
1390299 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390301 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390303 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390305 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390325 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 21
1390327 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 23
1390332 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390334 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390336 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390338 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390346 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390348 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_RET 18
1390356 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390358 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AF_IMP 18
1390366 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390368 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_RET 20
1390376 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390378 | Nivell 03 P03_PP | Model Group:05_CA_Pipes Planta tipus:1390331; 05_CA_AC_IMP 18
1390442 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390444 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390446 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390448 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390468 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 26
1390470 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 29
1390475 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390477 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390479 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390481 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390489 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390491 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_RET 23
1390499 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390501 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AF_IMP 23
1390509 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390511 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_RET 26
1390519 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390521 | Nivell 04 P04_PP | Model Group:05_CA_Pipes Planta tipus:1390474; 05_CA_AC_IMP 23
1390585 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390587 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390589 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390591 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390611 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 31
1390613 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 35
1390618 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
1390620 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390622 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390624 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390632 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390634 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_RET 28
1390642 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390644 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AF_IMP 28
1390652 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390654 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_RET 32
1390662 | Nivell 05 P05_PP | Model Group:05_CA_Pipes Planta tipus:1390617; 05_CA_AC_IMP 28
